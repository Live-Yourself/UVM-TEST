mXI0_MXPA3_4 Y C VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA3_5 Y C VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2_5 Y B VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_6 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_6 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3_6 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND3_X1_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA3 XI0_n1 C VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA2 XI0_n2 B XI0_n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA1 Y A XI0_n2 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT NAND3_X2_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA3 XI0_n1 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n2 B XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND3_X3_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA1_2 Y A XI0_n2__2 VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA2_2 XI0_n2__2 B XI0_n1__2 VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA3_2 XI0_n1__2 C VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA3 XI0_n1 C VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA2 XI0_n2 B XI0_n1 VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA1 Y A XI0_n2 VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA3_2 Y C VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT NAND3_X4_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA1_2 Y A XI0_n2__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 XI0_n2__2 B XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_2 XI0_n1__2 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3 XI0_n1 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n2 B XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3_2 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND3_X6_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA3_2 XI0_n1__2 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 XI0_n2__2 B XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A XI0_n2__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A XI0_n2__3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_3 XI0_n2__3 B XI0_n1__3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_3 XI0_n1__3 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3 XI0_n1 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n2 B XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA3_2 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3_3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_3 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT NAND3_X8_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA3_2 XI0_n1__2 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 XI0_n2__2 B XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A XI0_n2__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A XI0_n2__3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_3 XI0_n2__3 B XI0_n1__3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_3 XI0_n1__3 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_4 XI0_n1__4 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_4 XI0_n2__4 B XI0_n1__4 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A XI0_n2__4 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n2 B XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3 XI0_n1 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA3_2 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3_3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_3 Y B VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_4 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3_4 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND3_XL_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA3 XI0_n1 C VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 XI0_n2 B XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 Y A XI0_n2 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT NAND4BB_X1_A7TR Y VDD VNW VPW VSS AN BN C D
mXI0_MXNA1 A AN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net43 D VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN3 net47 C net43 VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN0 net51 B net47 VPW N18_DNW L=1.8e-07 W=4.2e-07
MXNA Y A net51 VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXNA1 B BN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA1 A AN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 Y D VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP1 Y C VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP0 Y B VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXPA Y A VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPA1 B BN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT NAND4BB_X2_A7TR Y VDD VNW VPW VSS AN BN C D
mXI0_MXNA1 A AN VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
MXN7 net43 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6 net47 C net43 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN5 net51 B net47 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNA Y A net51 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 B BN VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI0_MXPA1 A AN VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
MXP5 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP4 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP3 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXPA Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 B BN VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
.ends


.SUBCKT NAND4BB_X4_A7TR Y VDD VNW VPW VSS AN BN C D
mXI1_MXNA1 B BN VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN11_2 net43__2 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN10_2 net47__2 C net43__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN9_2 net51__2 B net47__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNA_2 Y A net51__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNA Y A net51 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN9 net51 B net47 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN10 net47 C net43 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN11 net43 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 A AN VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXPA1 B BN VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP5 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP6 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP7 Y B VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
MXPA Y A VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
MXPA_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP7_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP6_2 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP5_2 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 A AN VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
.ends


.SUBCKT NAND4BB_XL_A7TR Y VDD VNW VPW VSS AN BN C D
mXI0_MXNA1 A AN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN12 net43 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN11 net47 C net43 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net51 B net47 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXNA Y A net51 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 B BN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA1 A AN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP10 Y D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP9 Y C VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP8 Y B VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXPA Y A VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPA1 B BN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT NAND4B_X1_A7TR Y VDD VNW VPW VSS AN B C D
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA4 XI1_n1 D VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXNA3 XI1_n2 C XI1_n1 VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXNA2 XI1_n3 B XI1_n2 VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXNA1 Y a XI1_n3 VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA4 Y D VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPA1 Y a VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT NAND4B_X2_A7TR Y VDD VNW VPW VSS AN B C D
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI1_MXNA4 XI1_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA3 XI1_n2 C XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2 XI1_n3 B XI1_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y a XI1_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXPA4 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y a VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND4B_X4_A7TR Y VDD VNW VPW VSS AN B C D
mXI1_MXNA4_2 XI1_n1__2 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA3_2 XI1_n2__2 C XI1_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_2 XI1_n3__2 B XI1_n2__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y a XI1_n3__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y a XI1_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2 XI1_n3 B XI1_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA3 XI1_n2 C XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA4 XI1_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXPA4 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y a VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y a VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI1_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI1_MXPA3_2 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA4_2 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
.ends


.SUBCKT NAND4B_XL_A7TR Y VDD VNW VPW VSS AN B C D
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA4 XI1_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA3 XI1_n2 C XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 XI1_n3 B XI1_n2 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y a XI1_n3 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA4 Y D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPA1 Y a VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT NAND4_X12_A7TR Y VDD VNW VPW VSS A B C D
mXI0_MXNA4 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA4_2 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA4_3 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA4_4 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA4_5 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA4_6 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_2 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_3 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_4 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_5 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_6 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_3 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_4 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_5 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_6 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A XI0_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A XI0_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A XI0_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A XI0_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_5 Y A XI0_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_6 Y A XI0_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA4 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA4_2 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA4_3 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA4_4 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA4_5 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA4_6 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3_2 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3_3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3_4 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3_5 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3_6 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_3 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_4 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_5 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_6 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_6 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND4_X1_A7TR Y VDD VNW VPW VSS A B C D
mXI0_MXNA4 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA3 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA1 Y A XI0_n3 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA4 Y D VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT NAND4_X2_A7TR Y VDD VNW VPW VSS A B C D
mXI0_MXNA4 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A XI0_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA4 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND4_X4_A7TR Y VDD VNW VPW VSS A B C D
mXI0_MXNA4_2 XI0_n1__2 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_2 XI0_n2__2 C XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 XI0_n3__2 B XI0_n2__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A XI0_n3__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A XI0_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA4 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA4 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA3_2 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA4_2 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND4_X6_A7TR Y VDD VNW VPW VSS A B C D
mXI0_MXNA4 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA4_2 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA4_3 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_2 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_3 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_3 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A XI0_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A XI0_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A XI0_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA4 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA4_2 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA4_3 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3_2 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3_3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_3 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND4_X8_A7TR Y VDD VNW VPW VSS A B C D
mXI0_MXNA4 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA4_2 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA4_3 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA4_4 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_2 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_3 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_4 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_3 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_4 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A XI0_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A XI0_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A XI0_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A XI0_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA4 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA4_2 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA4_3 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA4_4 Y D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3_2 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3_3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3_4 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_3 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_4 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND4_XL_A7TR Y VDD VNW VPW VSS A B C D
mXI0_MXNA4 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA3 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 Y A XI0_n3 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA4 Y D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT NOR2B_X12_A7TR Y VDD VNW VPW VSS AN B
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXNA1_2 a AN VSS VPW N18_DNW L=1.8e-07 W=7.7e-07
mXI0_MXNA1_3 a AN VSS VPW N18_DNW L=1.8e-07 W=7.7e-07
mXI1_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y a VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y a VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_3 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y a VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI1_MXNA1_4 Y a VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_4 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_5 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_5 Y a VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_6 Y a VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_6 Y B VSS VPW N18_DNW L=1.8e-07 W=5.2e-07
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=9.6e-07
mXI0_MXPA1_2 a AN VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA1_3 a AN VDD VNW P18_DNW L=1.8e-07 W=1.09e-06
mXI1_MXPA2_2 XI1_p1__2 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y a XI1_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y a XI1_p1__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_3 XI1_p1__3 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_4 XI1_p1__4 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y a XI1_p1__4 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_5 Y a XI1_p1__5 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_5 XI1_p1__5 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_6 XI1_p1__6 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_6 Y a XI1_p1__6 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y a XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2 XI1_p1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NOR2B_X1_A7TR Y VDD VNW VPW VSS AN B
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXNA1 Y a VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2 XI1_p1 B VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPA1 Y a XI1_p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT NOR2B_X2_A7TR Y VDD VNW VPW VSS AN B
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI1_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y a VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXPA2 XI1_p1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y a XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NOR2B_X4_A7TR Y VDD VNW VPW VSS AN B
mXI1_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=5.2e-07
mXI1_MXNA1 Y a VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y a VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXPA2_2 XI1_p1__2 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y a XI1_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y a XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2 XI1_p1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
.ends


.SUBCKT NOR2B_X8_A7TR Y VDD VNW VPW VSS AN B
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI0_MXNA1_2 a AN VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
mXI1_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y a VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y a VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_3 Y B VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI1_MXNA1_3 Y a VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y a VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_4 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA1_2 a AN VDD VNW P18_DNW L=1.8e-07 W=1.03e-06
mXI1_MXPA2_2 XI1_p1__2 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y a XI1_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y a XI1_p1__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_3 XI1_p1__3 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_4 XI1_p1__4 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y a XI1_p1__4 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y a XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2 XI1_p1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NOR2B_XL_A7TR Y VDD VNW VPW VSS AN B
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y a VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2 XI1_p1 B VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPA1 Y a XI1_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT NOR2_X12_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_3 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_4 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_5 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_5 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_6 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_6 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA2_2 XI0_p1__2 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A XI0_p1__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_3 XI0_p1__3 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_4 XI0_p1__4 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y A XI0_p1__4 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_5 Y A XI0_p1__5 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_5 XI0_p1__5 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_6 XI0_p1__6 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_6 Y A XI0_p1__6 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 XI0_p1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NOR2_X1_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA2 XI0_p1 B VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPA1 Y A XI0_p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT NOR2_X2_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA2 XI0_p1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NOR2_X3_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI0_MXNA2_2 Y B VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI0_MXPA2_2 XI0_p1__2 B VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI0_MXPA1_2 Y A XI0_p1__2 VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI0_MXPA1 Y A XI0_p1 VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI0_MXPA2 XI0_p1 B VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
.ends


.SUBCKT NOR2_X4_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA2_2 XI0_p1__2 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 XI0_p1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NOR2_X5_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA2_2 Y B VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA2_3 Y B VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI0_MXPA2_2 XI0_p1__2 B VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI0_MXPA1_2 Y A XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI0_MXPA1_3 Y A XI0_p1__3 VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI0_MXPA2_3 XI0_p1__3 B VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI0_MXPA2 XI0_p1 B VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI0_MXPA1 Y A XI0_p1 VNW P18_DNW L=1.8e-07 W=1.1e-06
.ends


.SUBCKT NOR2_X6_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_3 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA2_2 XI0_p1__2 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A XI0_p1__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_3 XI0_p1__3 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 XI0_p1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NOR2_X8_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_3 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_4 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA2_2 XI0_p1__2 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A XI0_p1__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_3 XI0_p1__3 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_4 XI0_p1__4 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y A XI0_p1__4 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 XI0_p1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NOR2_XL_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA2 XI0_p1 B VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA1 Y A XI0_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT NOR3B_X1_A7TR Y VDD VNW VPW VSS AN B C
mX_g0_MXNA1 net38 AN VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MX_t5 Y C VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN0 Y B VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN1 Y net38 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g0_MXPA1 net38 AN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t0 VDD C net33 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP0 net33 B net30 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP1 net30 net38 Y VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT NOR3B_X2_A7TR Y VDD VNW VPW VSS AN B C
mX_g0_MXNA1 net38 AN VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MX_t5 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN3 Y net38 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXPA1 net38 AN VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
MX_t0 VDD C net33 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2 net33 B net30 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP3 net30 net38 Y VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NOR3B_X4_A7TR Y VDD VNW VPW VSS AN B C
mX_g0_MXNA1 net38 AN VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MX_t5 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN4 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN5 Y net38 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN5_2 Y net38 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN4_2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t5_2 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXPA1 net38 AN VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
MX_t0_2 VDD C net33__2 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP4_2 net33__2 B net30__2 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP5_2 net30__2 net38 Y VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP5 net30 net38 Y VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP4 net33 B net30 VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t0 VDD C net33 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NOR3B_XL_A7TR Y VDD VNW VPW VSS AN B C
mX_g0_MXNA1 net38 AN VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MX_t5 Y C VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN6 Y B VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN7 Y net38 VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g0_MXPA1 net38 AN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t0 VDD C net33 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP4 net33 B net30 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP5 net30 net38 Y VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT NOR3_X12_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA3 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_2 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_3 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_3 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_4 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_4 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_5 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_5 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_5 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_6 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_6 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_6 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA3_2 XI0_p1__2 C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 XI0_p2__2 B XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A XI0_p2__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A XI0_p2__3 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2_3 XI0_p2__3 B XI0_p1__3 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA3_3 XI0_p1__3 C VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA3_4 XI0_p1__4 C VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2_4 XI0_p2__4 B XI0_p1__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1_4 Y A XI0_p2__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1_5 Y A XI0_p2__5 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2_5 XI0_p2__5 B XI0_p1__5 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA3_5 XI0_p1__5 C VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA3_6 XI0_p1__6 C VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2_6 XI0_p2__6 B XI0_p1__6 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1_6 Y A XI0_p2__6 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1 Y A XI0_p2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 XI0_p2 B XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3 XI0_p1 C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NOR3_X1_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA3 Y C VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA3 XI0_p1 C VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPA2 XI0_p2 B XI0_p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPA1 Y A XI0_p2 VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT NOR3_X2_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA3 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA3 XI0_p1 C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 XI0_p2 B XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A XI0_p2 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NOR3_X4_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA3 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_2 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA3_2 XI0_p1__2 C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 XI0_p2__2 B XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A XI0_p2__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A XI0_p2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 XI0_p2 B XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3 XI0_p1 C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NOR3_X6_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA3 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_2 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_3 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_3 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI0_MXPA3_2 XI0_p1__2 C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 XI0_p2__2 B XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A XI0_p2__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A XI0_p2__3 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2_3 XI0_p2__3 B XI0_p1__3 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA3_3 XI0_p1__3 C VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA3 XI0_p1 C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 XI0_p2 B XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A XI0_p2 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NOR3_X8_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA3 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_2 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_3 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_3 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_4 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_4 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA3_2 XI0_p1__2 C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 XI0_p2__2 B XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A XI0_p2__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A XI0_p2__3 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2_3 XI0_p2__3 B XI0_p1__3 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA3_3 XI0_p1__3 C VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA3_4 XI0_p1__4 C VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2_4 XI0_p2__4 B XI0_p1__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1_4 Y A XI0_p2__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1 Y A XI0_p2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 XI0_p2 B XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3 XI0_p1 C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NOR3_XL_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA3 Y C VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 Y B VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA3 XI0_p1 C VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA2 XI0_p2 B XI0_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA1 Y A XI0_p2 VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT NOR4BB_X1_A7TR Y VDD VNW VPW VSS AN BN C D
mXI1_MXNA1 B BN VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN2 Y D VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN1 Y C VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN0 Y B VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXNA Y A VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA1 A AN VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 B BN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXPD net90 D VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP0 net86 C net90 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP1 net068 B net86 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2 Y A net068 VNW P18_DNW L=1.8e-07 W=1.21e-06
mXI0_MXPA1 A AN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT NOR4BB_X2_A7TR Y VDD VNW VPW VSS AN BN C D
mXI0_MXNA1 A AN VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXNA1 B BN VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN5 Y D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN4 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN3 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNA Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 A AN VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
mXI1_MXPA1 B BN VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP5_2 Y A net068__2 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP4_2 net068__2 B net86__2 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP3_2 net86__2 C net90__2 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXPD_2 net90__2 D VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXPD net90 D VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP3 net86 C net90 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP4 net068 B net86 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP5 Y A net068 VNW P18_DNW L=1.8e-07 W=1.21e-06
.ends


.SUBCKT NOR4BB_X4_A7TR Y VDD VNW VPW VSS AN BN C D
mXI0_MXNA1 A AN VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXNA1_2 A AN VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXNA1 B BN VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXNA1_2 B BN VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXNA Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN8 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN4 Y C VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN9 Y D VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN9_2 Y D VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN4_2 Y C VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN8_2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNA_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 A AN VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
mXI0_MXPA1_2 A AN VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI1_MXPA1 B BN VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
mXI1_MXPA1_2 B BN VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
MXP5_2 Y A net068__2 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP4_2 net068__2 B net86__2 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP6_2 net86__2 C net90__2 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP7_2 net90__2 D VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP7_3 net90__3 D VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP6_3 net86__3 C net90__3 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP4_3 net068__3 B net86__3 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP5_3 Y A net068__3 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP5_4 Y A net068__4 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP4_4 net068__4 B net86__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP6_4 net86__4 C net90__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP7_4 net90__4 D VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP7 net90 D VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP6 net86 C net90 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP4 net068 B net86 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP5 Y A net068 VNW P18_DNW L=1.8e-07 W=1.21e-06
.ends


.SUBCKT NOR4BB_XL_A7TR Y VDD VNW VPW VSS AN BN C D
mXI1_MXNA1 B BN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 Y D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 Y C VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 Y B VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXNA Y A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 A AN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXPA1 B BN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 net90 D VDD VNW P18_DNW L=1.8e-07 W=6e-07
MXP4 net86 C net90 VNW P18_DNW L=1.8e-07 W=6e-07
MXP3 net068 B net86 VNW P18_DNW L=1.8e-07 W=6e-07
MXP2 Y A net068 VNW P18_DNW L=1.8e-07 W=6e-07
mXI0_MXPA1 A AN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends

.SUBCKT NOR4B_X1_A7TR Y VDD VNW VPW VSS AN B C D
mXI0_MXNA1 A AN VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN2 Y D VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN1 Y C VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN0 Y B VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXNA Y A VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 A AN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXPD net33 D VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP0 net29 C net33 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP1 net25 B net29 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2 Y A net25 VNW P18_DNW L=1.8e-07 W=1.21e-06
.ends


.SUBCKT NOR4B_X2_A7TR Y VDD VNW VPW VSS AN B C D
mXI0_MXNA1 A AN VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN5 Y D VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN4 Y C VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN3 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNA Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 A AN VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
MXPA_2 Y A net25__2 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP0_2 net25__2 B net29__2 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP1_2 net29__2 C net33__2 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2_2 net33__2 D VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2 net33 D VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP1 net29 C net33 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP0 net25 B net29 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXPA Y A net25 VNW P18_DNW L=1.8e-07 W=1.21e-06
.ends


.SUBCKT NOR4B_X4_A7TR Y VDD VNW VPW VSS AN B C D
mXI0_MXNA1 A AN VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXNA1_2 A AN VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXNA Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN7 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN4 Y C VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN6 Y D VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN6_2 Y D VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN4_2 Y C VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN7_2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNA_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 A AN VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
mXI0_MXPA1_2 A AN VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
MXPA_2 Y A net25__2 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP3_2 net25__2 B net29__2 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP4_2 net29__2 C net33__2 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP5_2 net33__2 D VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP5_3 net33__3 D VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP4_3 net29__3 C net33__3 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP3_3 net25__3 B net29__3 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXPA_3 Y A net25__3 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXPA_4 Y A net25__4 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP3_4 net25__4 B net29__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP4_4 net29__4 C net33__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP5_4 net33__4 D VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP5 net33 D VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP4 net29 C net33 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP3 net25 B net29 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXPA Y A net25 VNW P18_DNW L=1.8e-07 W=1.21e-06
.ends


.SUBCKT NOR4B_XL_A7TR Y VDD VNW VPW VSS AN B C D
mXI0_MXNA1 A AN VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN9 Y D VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN8 Y C VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN7 Y B VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXNA Y A VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 A AN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP11 net33 D VDD VNW P18_DNW L=1.8e-07 W=6e-07
MXP10 net29 C net33 VNW P18_DNW L=1.8e-07 W=6e-07
MXP9 net25 B net29 VNW P18_DNW L=1.8e-07 W=6e-07
MXP8 Y A net25 VNW P18_DNW L=1.8e-07 W=6e-07
.ends


.SUBCKT NOR4_X12_A7TR Y VDD VNW VPW VSS A B C D
MXNA Y A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNB Y B VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNC Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN4 Y D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN4_2 Y D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNC_2 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNB_2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNA_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNA_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNB_3 Y B VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNC_3 Y C VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN4_3 Y D VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN4_4 Y D VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNC_4 Y C VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNB_4 Y B VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNA_4 Y A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNA_5 Y A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNB_5 Y B VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNC_5 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN4_5 Y D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN4_6 Y D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNC_6 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNB_6 Y B VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNA_6 Y A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXP8_2 net43__2 D VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
MXP7_2 net40__2 C net43__2 VNW P18_DNW L=1.8e-07 W=9.8e-07
MXP5_2 net37__2 B net40__2 VNW P18_DNW L=1.8e-07 W=9.8e-07
MXPA_2 Y A net37__2 VNW P18_DNW L=1.8e-07 W=9.8e-07
MXPA_3 Y A net37__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP5_3 net37__3 B net40__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP7_3 net40__3 C net43__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8_3 net43__3 D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8_4 net43__4 D VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP7_4 net40__4 C net43__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP5_4 net37__4 B net40__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXPA_4 Y A net37__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXPA_5 Y A net37__5 VNW P18_DNW L=1.8e-07 W=1.14e-06
MXP5_5 net37__5 B net40__5 VNW P18_DNW L=1.8e-07 W=1.14e-06
MXP7_5 net40__5 C net43__5 VNW P18_DNW L=1.8e-07 W=1.14e-06
MXP8_5 net43__5 D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8_6 net43__6 D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP7_6 net40__6 C net43__6 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP5_6 net37__6 B net40__6 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXPA_6 Y A net37__6 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXPA_7 Y A net37__7 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP5_7 net37__7 B net40__7 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP7_7 net40__7 C net43__7 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP8_7 net43__7 D VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP8_8 net43__8 D VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP7_8 net40__8 C net43__8 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP5_8 net37__8 B net40__8 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXPA_8 Y A net37__8 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXPA_9 Y A net37__9 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP5_9 net37__9 B net40__9 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP7_9 net40__9 C net43__9 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP8_9 net43__9 D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8_10 net43__10 D VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
MXP7_10 net40__10 C net43__10 VNW P18_DNW L=1.8e-07 W=1.14e-06
MXP5_10 net37__10 B net40__10 VNW P18_DNW L=1.8e-07 W=1.14e-06
MXPA_10 Y A net37__10 VNW P18_DNW L=1.8e-07 W=1.14e-06
MXPA_11 Y A net37__11 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP5_11 net37__11 B net40__11 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP7_11 net40__11 C net43__11 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP8_11 net43__11 D VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP8_12 net43__12 D VDD VNW P18_DNW L=1.8e-07 W=1.24e-06
MXP7_12 net40__12 C net43__12 VNW P18_DNW L=1.8e-07 W=1.24e-06
MXP5_12 net37__12 B net40__12 VNW P18_DNW L=1.8e-07 W=1.24e-06
MXPA_12 Y A net37__12 VNW P18_DNW L=1.8e-07 W=1.24e-06
MXPA Y A net37 VNW P18_DNW L=1.8e-07 W=1.24e-06
MXP5 net37 B net40 VNW P18_DNW L=1.8e-07 W=1.24e-06
MXP7 net40 C net43 VNW P18_DNW L=1.8e-07 W=1.24e-06
MXP8 net43 D VDD VNW P18_DNW L=1.8e-07 W=1.24e-06
.ends


.SUBCKT NOR4_X1_A7TR Y VDD VNW VPW VSS A B C D
MXN7 Y D VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN6 Y C VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN5 Y B VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXNA Y A VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXP8 net43 D VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP9 net40 C net43 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP10 net37 B net40 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP11 Y A net37 VNW P18_DNW L=1.8e-07 W=1.21e-06
.ends


.SUBCKT NOR4_X2_A7TR Y VDD VNW VPW VSS A B C D
MXNA Y A VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN8 Y B VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN9 Y C VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN10 Y D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP8_2 net43__2 D VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP12_2 net40__2 C net43__2 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP13_2 net37__2 B net40__2 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP14_2 Y A net37__2 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP14 Y A net37 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP13 net37 B net40 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP12 net40 C net43 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP8 net43 D VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
.ends


.SUBCKT NOR4_X4_A7TR Y VDD VNW VPW VSS A B C D
MXN14 Y D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN9 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN13 Y B VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNA Y A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNA_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN13_2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN9_2 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN14_2 Y D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP8_2 net43__2 D VDD VNW P18_DNW L=1.8e-07 W=9.6e-07
MXP12_2 net40__2 C net43__2 VNW P18_DNW L=1.8e-07 W=9.6e-07
MXP17_2 net37__2 B net40__2 VNW P18_DNW L=1.8e-07 W=9.6e-07
MXP18_2 Y A net37__2 VNW P18_DNW L=1.8e-07 W=9.6e-07
MXP18_3 Y A net37__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP17_3 net37__3 B net40__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP12_3 net40__3 C net43__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8_3 net43__3 D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8_4 net43__4 D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP12_4 net40__4 C net43__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP17_4 net37__4 B net40__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP18_4 Y A net37__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP18 Y A net37 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP17 net37 B net40 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP12 net40 C net43 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8 net43 D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NOR4_X6_A7TR Y VDD VNW VPW VSS A B C D
MXNA Y A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN11 Y B VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN9 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN13 Y D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN13_2 Y D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN9_2 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN11_2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNA_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNA_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN11_3 Y B VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN9_3 Y C VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN13_3 Y D VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXP8_2 net43__2 D VDD VNW P18_DNW L=1.8e-07 W=9.6e-07
MXP12_2 net40__2 C net43__2 VNW P18_DNW L=1.8e-07 W=9.6e-07
MXP17_2 net37__2 B net40__2 VNW P18_DNW L=1.8e-07 W=9.6e-07
MXP18_2 Y A net37__2 VNW P18_DNW L=1.8e-07 W=9.6e-07
MXP18_3 Y A net37__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP17_3 net37__3 B net40__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP12_3 net40__3 C net43__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8_3 net43__3 D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8_4 net43__4 D VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP12_4 net40__4 C net43__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP17_4 net37__4 B net40__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP18_4 Y A net37__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP18_5 Y A net37__5 VNW P18_DNW L=1.8e-07 W=1.14e-06
MXP17_5 net37__5 B net40__5 VNW P18_DNW L=1.8e-07 W=1.14e-06
MXP12_5 net40__5 C net43__5 VNW P18_DNW L=1.8e-07 W=1.14e-06
MXP8_5 net43__5 D VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP8_6 net43__6 D VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP12_6 net40__6 C net43__6 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP17_6 net37__6 B net40__6 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP18_6 Y A net37__6 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP18 Y A net37 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP17 net37 B net40 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP12 net40 C net43 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP8 net43 D VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
.ends


.SUBCKT NOR4_X8_A7TR Y VDD VNW VPW VSS A B C D
MXN14 Y D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN9 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN11 Y B VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNA Y A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNA_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN11_2 Y B VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN9_2 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN14_2 Y D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN14_3 Y D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN9_3 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN11_3 Y B VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNA_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXNA_4 Y A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN11_4 Y B VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN9_4 Y C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN14_4 Y D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP8_2 net43__2 D VDD VNW P18_DNW L=1.8e-07 W=9.6e-07
MXP12_2 net40__2 C net43__2 VNW P18_DNW L=1.8e-07 W=9.6e-07
MXP19_2 net37__2 B net40__2 VNW P18_DNW L=1.8e-07 W=9.6e-07
MXP20_2 Y A net37__2 VNW P18_DNW L=1.8e-07 W=9.6e-07
MXP20_3 Y A net37__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP19_3 net37__3 B net40__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP12_3 net40__3 C net43__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8_3 net43__3 D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8_4 net43__4 D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP12_4 net40__4 C net43__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP19_4 net37__4 B net40__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP20_4 Y A net37__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP20_5 Y A net37__5 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP19_5 net37__5 B net40__5 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP12_5 net40__5 C net43__5 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP8_5 net43__5 D VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP8_6 net43__6 D VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP12_6 net40__6 C net43__6 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP19_6 net37__6 B net40__6 VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP20_6 Y A net37__6 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP20_7 Y A net37__7 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP19_7 net37__7 B net40__7 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP12_7 net40__7 C net43__7 VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP8_7 net43__7 D VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
MXP8_8 net43__8 D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP12_8 net40__8 C net43__8 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP19_8 net37__8 B net40__8 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP20_8 Y A net37__8 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP20 Y A net37 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP19 net37 B net40 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP12 net40 C net43 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8 net43 D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NOR4_XL_A7TR Y VDD VNW VPW VSS A B C D
MXN10 Y D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 Y C VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 Y B VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXNA Y A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXP8 net43 D VDD VNW P18_DNW L=1.8e-07 W=6e-07
MXP12 net40 C net43 VNW P18_DNW L=1.8e-07 W=6e-07
MXP13 net37 B net40 VNW P18_DNW L=1.8e-07 W=6e-07
MXP14 Y A net37 VNW P18_DNW L=1.8e-07 W=6e-07
.ends


.SUBCKT OA21_X1_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXNB1 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXNA1 ny B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPB1 ny A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 ny B0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
.ends


.SUBCKT OA21_X2_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI0_MXNB1 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
mXI0_MXNA1 ny B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=3.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXPB1 ny A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXPA1 ny B0 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
.ends


.SUBCKT OA21_X4_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 ny B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPB1 ny A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA1 ny B0 VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OA21_X8_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2_2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1_2 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 ny B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 ny B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB2_2 XI0_p1__2 A1 VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPB1_2 ny A0 XI0_p1__2 VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPB1 ny A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1 ny B0 VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA1_2 ny B0 VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OA21_XL_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXNB1 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXNA1 ny B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPB1 ny A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 ny B0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT OA22_X1_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
MXN6 ny A1 net45 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 ny A0 net45 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net45 B0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net45 B1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXP6 net60 A1 VDD VNW P18_DNW L=1.8e-07 W=4.3e-07
MXP5 ny A0 net60 VNW P18_DNW L=1.8e-07 W=4.3e-07
MXP4 ny B0 net66 VNW P18_DNW L=1.8e-07 W=4.3e-07
MXP8 net66 B1 VDD VNW P18_DNW L=1.8e-07 W=4.3e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT OA22_X2_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
MXN6 ny A1 net45 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN7 ny A0 net45 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN8 net45 B0 VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN9 net45 B1 VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP7 net60 A1 VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
MXP9 ny A0 net60 VNW P18_DNW L=1.8e-07 W=6.8e-07
MXP10 ny B0 net66 VNW P18_DNW L=1.8e-07 W=6.8e-07
MXP8 net66 B1 VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OA22_X4_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
MXN6 ny A1 net45 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN10 ny A0 net45 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN11 net45 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN12 net45 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP11 net60 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP12 ny A0 net60 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP13 ny B0 net66 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8 net66 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OA22_X8_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
MXN13 ny A0 net45 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6 ny A1 net45 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6_2 ny A1 net45 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN13_2 ny A0 net45 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN14 net45 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN15 net45 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN15_2 net45 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN14_2 net45 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP15_2 ny A0 net60__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP14_2 net60__2 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP14 net60 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP15 ny A0 net60 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP16_2 ny B0 net66__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8_2 net66__2 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8 net66 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP16 ny B0 net66 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OA22_XL_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
MXN6 ny A1 net45 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 ny A0 net45 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net45 B0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 net45 B1 VSS VPW N18_DNW L=1.8e-07 W=2.4e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXP7 net60 A1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9 ny A0 net60 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP10 ny B0 net66 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 net66 B1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT OAI211_X1_A7TR Y VDD VNW VPW VSS A0 A1 B0 C0
mXI0_MXNC1 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNC2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNB1 XI0_n2 C0 XI0_n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA1 Y B0 XI0_n2 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPC1 Y A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPC2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPB1 Y C0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT OAI211_X2_A7TR Y VDD VNW VPW VSS A0 A1 B0 C0
mXI0_MXNC1 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNC2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 XI0_n2 C0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y B0 XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPC1 Y A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPC2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1 Y C0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI211_X4_A7TR Y VDD VNW VPW VSS A0 A1 B0 C0
mXI0_MXNC1 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNC2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNC2_2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNC1_2 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1_2 XI0_n2__2 C0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y B0 XI0_n2__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y B0 XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 XI0_n2 C0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPC1_2 Y A0 XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPC2_2 XI0_p1__2 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPC2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPC1 Y A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1 Y C0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_2 Y C0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI211_X8_A7TR Y VDD VNW VPW VSS A0 A1 B0 C0
mXI0_MXNC1 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNC2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNC2_2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNC1_2 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNC1_3 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNC2_3 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNC2_4 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNC1_4 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1_2 XI0_n2__2 C0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y B0 XI0_n2__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y B0 XI0_n2__3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1_3 XI0_n2__3 C0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1_4 XI0_n2__4 C0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y B0 XI0_n2__4 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y B0 XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 XI0_n2 C0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPC1_2 Y A0 XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPC2_2 XI0_p1__2 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPC2_3 XI0_p1__3 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPC1_3 Y A0 XI0_p1__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPC1_4 Y A0 XI0_p1__4 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPC2_4 XI0_p1__4 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPC2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPC1 Y A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1 Y C0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_2 Y C0 VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPB1_3 Y C0 VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1_3 Y B0 VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_4 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_4 Y C0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI211_XL_A7TR Y VDD VNW VPW VSS A0 A1 B0 C0
mXI0_MXNC1 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNC2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNB1 XI0_n2 C0 XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 Y B0 XI0_n2 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPC1 Y A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPC2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPB1 Y C0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT OAI21B_X1_A7TR Y VDD VNW VPW VSS A0 A1 B0N
mXI1_MXNB2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXNB1 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXNA1 Y b0 XI1_n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA1 b0 B0N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXPB2 XI1_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
mXI1_MXPB1 Y A0 XI1_p1 VNW P18_DNW L=1.8e-07 W=8.5e-07
mXI1_MXPA1 Y b0 VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
mXI0_MXPA1 b0 B0N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT OAI21B_X2_A7TR Y VDD VNW VPW VSS A0 A1 B0N
mXI1_MXNB2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y b0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 b0 B0N VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI1_MXPB2 XI1_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1 Y A0 XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y b0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 b0 B0N VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
.ends


.SUBCKT OAI21B_X4_A7TR Y VDD VNW VPW VSS A0 A1 B0N
mXI1_MXNB2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1_2 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2_2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y b0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y b0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 b0 B0N VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI1_MXPB2_2 XI1_p1__2 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1_2 Y A0 XI1_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1 Y A0 XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB2 XI1_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y b0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y b0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 b0 B0N VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT OAI21B_X8_A7TR Y VDD VNW VPW VSS A0 A1 B0N
mXI1_MXNB2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1_2 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2_2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2_3 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1_3 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1_4 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2_4 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y b0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y b0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y b0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y b0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 b0 B0N VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXPB2_2 XI1_p1__2 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1_2 Y A0 XI1_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1_3 Y A0 XI1_p1__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB2_3 XI1_p1__3 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB2_4 XI1_p1__4 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1_4 Y A0 XI1_p1__4 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1 Y A0 XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB2 XI1_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y b0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y b0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y b0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y b0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 b0 B0N VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI21B_XL_A7TR Y VDD VNW VPW VSS A0 A1 B0N
mXI1_MXNB2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNB1 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y b0 XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 b0 B0N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXPB2 XI1_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPB1 Y A0 XI1_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPA1 Y b0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA1 b0 B0N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT OAI21_X1_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNB1 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA1 Y B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPB1 Y A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT OAI21_X2_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1 Y A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI21_X3_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNB1 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNB1_2 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNB2_2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA1 Y B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA1_2 Y B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXPB2_2 XI0_p1__2 A1 VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI0_MXPB1_2 Y A0 XI0_p1__2 VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI0_MXPB1 Y A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI0_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI0_MXPA1_2 Y B0 VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
.ends


.SUBCKT OAI21_X4_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1_2 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2_2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB2_2 XI0_p1__2 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_2 Y A0 XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1 Y A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI21_X6_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1_2 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2_2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2_3 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1_3 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB2_2 XI0_p1__2 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_2 Y A0 XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_3 Y A0 XI0_p1__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2_3 XI0_p1__3 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1 Y A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI21_X8_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1_2 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2_2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2_3 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1_3 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNB1_4 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2_4 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB2_2 XI0_p1__2 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_2 Y A0 XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_3 Y A0 XI0_p1__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2_3 XI0_p1__3 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2_4 XI0_p1__4 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_4 Y A0 XI0_p1__4 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1 Y A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI21_XL_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNB1 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 Y B0 XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPB1 Y A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT OAI221_X1_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1 C0
MXN2 net33 B0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN3 net33 B1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN0 net25 A1 net33 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN1 net25 A0 net33 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN6 Y C0 net25 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXP0 Y B0 net46 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP8 net46 B1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP2 net58 A1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP1 Y A0 net58 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP3 Y C0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT OAI221_X2_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1 C0
MXN7 net33 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN5 net33 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN4 net25 A1 net33 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN8 net25 A0 net33 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6 Y C0 net25 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP5 Y B0 net073 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP4 net073 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP6 net059 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP7 Y A0 net059 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP3 Y C0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI221_X4_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1 C0
MXN11 net33 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN10 net33 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN10_2 net33 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN11_2 net33 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN12 net25 A0 net33 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN9 net25 A1 net33 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN9_2 net25 A1 net33 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN12_2 net25 A0 net33 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6 Y C0 net25 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6_2 Y C0 net25 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP9_2 Y B0 net077__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8_2 net077__2 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8 net077 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP9 Y B0 net077 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP11_2 Y A0 net069__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP10_2 net069__2 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP10 net069 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP11 Y A0 net069 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP3 Y C0 VDD VNW P18_DNW L=1.8e-07 W=1.17e-06
MXP3_2 Y C0 VDD VNW P18_DNW L=1.8e-07 W=1.17e-06
.ends


.SUBCKT OAI221_XL_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1 C0
MXN10 net33 B0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net33 B1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net25 A1 net33 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 net25 A0 net33 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 Y C0 net25 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXP5 Y B0 net069 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP4 net069 B1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP7 net077 A1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP6 Y A0 net077 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP3 Y C0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT OAI222_X1_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1 C0 C1
MXN2 net28 B0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN1 net28 B1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN0 net24 A1 net28 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN3 net24 A0 net28 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN6 Y C0 net24 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN4 Y C1 net24 VPW N18_DNW L=1.8e-07 W=3.8e-07
MXP6 Y B0 net089 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP5 net089 B1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP9 net083 A1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP10 Y A0 net083 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP7 Y C0 net59 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP8 net59 C1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT OAI222_X2_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1 C0 C1
MXN8 net28 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN10 net28 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN9 net24 A1 net28 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN7 net24 A0 net28 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6 Y C0 net24 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN5 Y C1 net24 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP22 Y B0 net094 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP11 net094 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP20 net088 A1 VDD VNW P18_DNW L=1.8e-07 W=1.2e-06
MXP21 Y A0 net088 VNW P18_DNW L=1.8e-07 W=1.2e-06
MXP18 Y C0 net0100 VNW P18_DNW L=1.8e-07 W=1.14e-06
MXP17 net0100 C1 VDD VNW P18_DNW L=1.8e-07 W=1.14e-06
.ends


.SUBCKT OAI222_X4_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1 C0 C1
MXN13 net28 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN15 net28 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN15_2 net28 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN13_2 net28 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN12 net24 A0 net28 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN14 net24 A1 net28 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN14_2 net24 A1 net28 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN12_2 net24 A0 net28 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6 Y C0 net24 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN11 Y C1 net24 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN11_2 Y C1 net24 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6_2 Y C0 net24 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP19_2 Y B0 net082__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP16_2 net082__2 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP16 net082 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP19 Y B0 net082 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP18_2 Y A0 net092__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP17_2 net092__2 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP17 net092 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP18 Y A0 net092 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP20_2 Y C0 net59__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8_2 net59__2 C1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8 net59 C1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP20 Y C0 net59 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI222_XL_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1 C0 C1
MXN2 net28 B0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 net28 B1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 net24 A1 net28 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 net24 A0 net28 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 Y C0 net24 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 Y C1 net24 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXP14 Y B0 net082 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP11 net082 B1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP12 net086 A1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP13 Y A0 net086 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP15 Y C0 net59 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP8 net59 C1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT OAI22_X1_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
MXN6 Y A1 net072 VPW N18_DNW L=1.8e-07 W=3.8e-07
MXN0 Y A0 net072 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN1 net072 B0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN2 net072 B1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXP0 net22 A1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP1 Y A0 net22 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP2 Y B0 net32 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP8 net32 B1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT OAI22_X2_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
MXN6 Y A1 net072 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN3 Y A0 net072 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN4 net072 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN5 net072 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP3 net22 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP4 Y A0 net22 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP5 Y B0 net32 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8 net32 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI22_X4_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
MXN3 Y A0 net072 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6 Y A1 net072 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6_2 Y A1 net072 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN3_2 Y A0 net072 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN4 net072 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN5 net072 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN5_2 net072 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN4_2 net072 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP4_2 Y A0 net22__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP3_2 net22__2 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP3 net22 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP4 Y A0 net22 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP5_2 Y B0 net32__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8_2 net32__2 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8 net32 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP5 Y B0 net32 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI22_X8_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
MXN8 net072 B0 VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
MXN9 net072 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN9_2 net072 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN8_2 net072 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN8_3 net072 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN9_3 net072 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN9_4 net072 B1 VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
MXN8_4 net072 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN7 Y A0 net072 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6 Y A1 net072 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6_2 Y A1 net072 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN7_2 Y A0 net072 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN7_3 Y A0 net072 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6_3 Y A1 net072 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6_4 Y A1 net072 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN7_4 Y A0 net072 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP9_2 Y B0 net32__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8_2 net32__2 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8_3 net32__3 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP9_3 Y B0 net32__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP9_4 Y B0 net32__4 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8_4 net32__4 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8 net32 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP9 Y B0 net32 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP7_2 Y A0 net22__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP6_2 net22__2 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP6_3 net22__3 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP7_3 Y A0 net22__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP7_4 Y A0 net22__4 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP6_4 net22__4 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP6 net22 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP7 Y A0 net22 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI22_XL_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
MXN6 Y A1 net072 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 Y A0 net072 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net072 B0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net072 B1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXP3 net22 A1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP4 Y A0 net22 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP5 Y B0 net32 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP8 net32 B1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT OAI2B11_X1_A7TR Y VDD VNW VPW VSS A0 A1N B0 C0
mXI0_MXNA1 A1 A1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNC1 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXNC2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXNB1 XI1_n2 C0 XI1_n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXNA1 Y B0 XI1_n2 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA1 A1 A1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPC1 Y A0 XI1_p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPC2 XI1_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPB1 Y C0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT OAI2B11_X2_A7TR Y VDD VNW VPW VSS A0 A1N B0 C0
mXI0_MXNA1 A1 A1N VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI1_MXNC1 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNC2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1 XI1_n2 C0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y B0 XI1_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 A1 A1N VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXPC1 Y A0 XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPC2 XI1_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1 Y C0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI2B11_X4_A7TR Y VDD VNW VPW VSS A0 A1N B0 C0
mXI0_MXNA1 A1 A1N VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXNC2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNC1 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNC1_2 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNC2_2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1_2 XI1_n2__2 C0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y B0 XI1_n2__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y B0 XI1_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1 XI1_n2 C0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 A1 A1N VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI1_MXPC2_2 XI1_p1__2 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPC1_2 Y A0 XI1_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPC1 Y A0 XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPC2 XI1_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1 Y C0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1_2 Y C0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI2B11_XL_A7TR Y VDD VNW VPW VSS A0 A1N B0 C0
mXI1_MXNC1 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNC2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNB1 XI1_n2 C0 XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y B0 XI1_n2 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 A1 A1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXPC1 Y A0 XI1_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPC2 XI1_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPB1 Y C0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA1 A1 A1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT OAI2B1_X1_A7TR Y VDD VNW VPW VSS A0 A1N B0
mXI0_MXNA1 A1 A1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNB2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXNB1 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXNA1 Y B0 XI1_n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA1 A1 A1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPB2 XI1_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPB1 Y A0 XI1_p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT OAI2B1_X2_A7TR Y VDD VNW VPW VSS A0 A1N B0
mXI0_MXNA1 A1 A1N VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI1_MXNB2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y B0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 A1 A1N VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXPB2 XI1_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1 Y A0 XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI2B1_X4_A7TR Y VDD VNW VPW VSS A0 A1N B0
mXI0_MXNA1 A1 A1N VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXNB2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2_2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y B0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y B0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1_2 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 A1 A1N VDD VNW P18_DNW L=1.8e-07 W=9.6e-07
mXI1_MXPB2 XI1_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB2_2 XI1_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1 Y A0 XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1_2 Y A0 XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI2B1_X8_A7TR Y VDD VNW VPW VSS A0 A1N B0
mXI0_MXNA1 A1 A1N VSS VPW N18_DNW L=1.8e-07 W=5.2e-07
mXI0_MXNA1_2 A1 A1N VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
mXI1_MXNB2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1_2 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2_2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2_3 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1_3 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1_4 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2_4 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y B0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y B0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y B0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y B0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 A1 A1N VDD VNW P18_DNW L=1.8e-07 W=1e-06
mXI0_MXPA1_2 A1 A1N VDD VNW P18_DNW L=1.8e-07 W=1.05e-06
mXI1_MXPB2_2 XI1_p1__2 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1_2 Y A0 XI1_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1_3 Y A0 XI1_p1__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB2_3 XI1_p1__3 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB2_4 XI1_p1__4 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1_4 Y A0 XI1_p1__4 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1 Y A0 XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB2 XI1_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI2B1_XL_A7TR Y VDD VNW VPW VSS A0 A1N B0
mXI0_MXNA1 A1 A1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNB2 XI1_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNB1 XI1_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y B0 XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA1 A1 A1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPB2 XI1_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPB1 Y A0 XI1_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPA1 Y B0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT OAI2B2_X1_A7TR Y VDD VNW VPW VSS A0 A1N B0 B1
mXI0_MXNA1 A1 A1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 Y A1 XI1_n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXNA1 Y A0 XI1_n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXNB1 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXNB2 XI1_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA1 A1 A1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2 XI1_p1A A1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPA1 Y A0 XI1_p1A VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPB1 Y B0 XI1_p1B VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPB2 XI1_p1B B1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT OAI2B2_X2_A7TR Y VDD VNW VPW VSS A0 A1N B0 B1
mXI0_MXNA1 A1 A1N VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI1_MXNA2 Y A1 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y A0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2 XI1_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 A1 A1N VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXPA2 XI1_p1A A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y A0 XI1_p1A VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1 Y B0 XI1_p1B VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB2 XI1_p1B B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI2B2_X4_A7TR Y VDD VNW VPW VSS A0 A1N B0 B1
mXI0_MXNA1 A1 A1N VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXNA2 Y A1 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y A0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y A0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_2 Y A1 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2 XI1_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1_2 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2_2 XI1_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 A1 A1N VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI1_MXPA2_2 XI1_p1A__2 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y A0 XI1_p1A__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y A0 XI1_p1A VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2 XI1_p1A A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB2_2 XI1_p1B__2 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1_2 Y B0 XI1_p1B__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1 Y B0 XI1_p1B VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB2 XI1_p1B B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI2B2_X8_A7TR Y VDD VNW VPW VSS A0 A1N B0 B1
mXI0_MXNA1 A1 A1N VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA1_2 A1 A1N VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXNA2 Y A1 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y A0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y A0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_2 Y A1 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_3 Y A1 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y A0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y A0 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_4 Y A1 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2 XI1_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI1_MXNB1_2 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2_2 XI1_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2_3 XI1_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1_3 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1_4 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2_4 XI1_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 A1 A1N VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA1_2 A1 A1N VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI1_MXPA2_2 XI1_p1A__2 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y A0 XI1_p1A__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y A0 XI1_p1A__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_3 XI1_p1A__3 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_4 XI1_p1A__4 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y A0 XI1_p1A__4 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y A0 XI1_p1A VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2 XI1_p1A A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB2_2 XI1_p1B__2 B1 VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI1_MXPB1_2 Y B0 XI1_p1B__2 VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI1_MXPB1_3 Y B0 XI1_p1B__3 VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI1_MXPB2_3 XI1_p1B__3 B1 VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI1_MXPB2_4 XI1_p1B__4 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1_4 Y B0 XI1_p1B__4 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1 Y B0 XI1_p1B VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB2 XI1_p1B B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI2B2_XL_A7TR Y VDD VNW VPW VSS A0 A1N B0 B1
mXI0_MXNA1 A1 A1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 Y A1 XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y A0 XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNB1 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNB2 XI1_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA1 A1 A1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2 XI1_p1A A1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPA1 Y A0 XI1_p1A VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPB1 Y B0 XI1_p1B VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPB2 XI1_p1B B1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT OAI2BB1_X1_A7TR Y VDD VNW VPW VSS A0N A1N B0
mXI0_MXNA1 nmin1 A1N XI0_n1 VPW N18_DNW L=1.8e-07 W=3.2e-07
mXI0_MXNA2 XI0_n1 A0N VSS VPW N18_DNW L=1.8e-07 W=3.2e-07
mXI1_MXNA2 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXNA1 Y nmin1 XI1_n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA1 nmin1 A1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA2 nmin1 A0N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2 Y B0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPA1 Y nmin1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT OAI2BB1_X2_A7TR Y VDD VNW VPW VSS A0N A1N B0
mXI0_MXNA1 nmin1 A1N XI0_n1 VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXNA2 XI0_n1 A0N VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXNA2 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y nmin1 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 nmin1 A1N VDD VNW P18_DNW L=1.8e-07 W=5.8e-07
mXI0_MXPA2 nmin1 A0N VDD VNW P18_DNW L=1.8e-07 W=5.8e-07
mXI1_MXPA2 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y nmin1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI2BB1_X4_A7TR Y VDD VNW VPW VSS A0N A1N B0
mXI0_MXNA1 nmin1 A1N XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n1 A0N VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_2 XI1_n1__2 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y nmin1 XI1_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y nmin1 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 nmin1 A1N VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2 nmin1 A0N VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI1_MXPA2 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y nmin1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y nmin1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_2 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI2BB1_XL_A7TR Y VDD VNW VPW VSS A0N A1N B0
mXI0_MXNA1 nmin1 A1N XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 XI0_n1 A0N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y nmin1 XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA1 nmin1 A1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA2 nmin1 A0N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2 Y B0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPA1 Y nmin1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT OAI2BB2_X1_A7TR Y VDD VNW VPW VSS A0N A1N B0 B1
mXI0_MXNA2 XI0_n1 A0N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 nmin1 A1N XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNB2 XI1_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXNB1 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXNA1 Y nmin1 XI1_n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA2 nmin1 A0N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 nmin1 A1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPB2 XI1_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPB1 Y B0 XI1_p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPA1 Y nmin1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT OAI2BB2_X2_A7TR Y VDD VNW VPW VSS A0N A1N B0 B1
mXI0_MXNA1 nmin1 A1N XI0_n1 VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI0_MXNA2 XI0_n1 A0N VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI1_MXNB2 XI1_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y nmin1 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 nmin1 A1N VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXPA2 nmin1 A0N VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXPB2 XI1_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1 Y B0 XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y nmin1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI2BB2_X4_A7TR Y VDD VNW VPW VSS A0N A1N B0 B1
mXI0_MXNA1 nmin1 A1N XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n1 A0N VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y nmin1 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y nmin1 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2 XI1_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1_2 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2_2 XI1_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 nmin1 A1N VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA2 nmin1 A0N VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI1_MXPA1 Y nmin1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y nmin1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB2_2 XI1_p1__2 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1_2 Y B0 XI1_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1 Y B0 XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB2 XI1_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI2BB2_X8_A7TR Y VDD VNW VPW VSS A0N A1N B0 B1
mXI0_MXNA1_2 nmin1 A1N XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 XI0_n1__2 A0N VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n1 A0N VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1 nmin1 A1N XI0_n1 VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI1_MXNA1 Y nmin1 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y nmin1 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y nmin1 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y nmin1 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2 XI1_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI1_MXNB1_2 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2_2 XI1_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2_3 XI1_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1_3 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB1_4 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNB2_4 XI1_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXPA1 nmin1 A1N VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA2 nmin1 A0N VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA2_2 nmin1 A0N VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA1_2 nmin1 A1N VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI1_MXPA1 Y nmin1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y nmin1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y nmin1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y nmin1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB2_2 XI1_p1__2 B1 VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI1_MXPB1_2 Y B0 XI1_p1__2 VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI1_MXPB1_3 Y B0 XI1_p1__3 VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI1_MXPB2_3 XI1_p1__3 B1 VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI1_MXPB2_4 XI1_p1__4 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1_4 Y B0 XI1_p1__4 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB1 Y B0 XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPB2 XI1_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI2BB2_XL_A7TR Y VDD VNW VPW VSS A0N A1N B0 B1
mXI0_MXNA2 XI0_n1 A0N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 nmin1 A1N XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNB2 XI1_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNB1 XI1_n1 B0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y nmin1 XI1_n1 VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA2 nmin1 A0N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 nmin1 A1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPB2 XI1_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPB1 Y B0 XI1_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPA1 Y nmin1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT OAI31_X1_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0
MXN3 n1 A2 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN2 n1 A1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN1 n1 A0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXNB0 Y B0 n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXPA2 net42 A2 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP1 net039 A1 net42 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP2 Y A0 net039 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP3 Y B0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT OAI31_X2_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0
MXN6 n1 A2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN5 n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN4 n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNB0 Y B0 n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXPA2 net42 A2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP4 net039 A1 net42 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP5 Y A0 net039 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP6 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI31_X4_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0
MXN9 n1 A2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN8 n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN7 n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN7_2 n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN8_2 n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN9_2 n1 A2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNB0 Y B0 n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNB0_2 Y B0 n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXPA2_2 net42__2 A2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP10_2 net039__2 A1 net42__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP11_2 Y A0 net039__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP11 Y A0 net039 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP10 net039 A1 net42 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXPA2 net42 A2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP9 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP9_2 Y B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI31_XL_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0
MXN6 n1 A2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 n1 A1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 n1 A0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXNB0 Y B0 n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXPA2 net42 A2 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP4 net039 A1 net42 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP5 Y A0 net039 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP6 Y B0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT OAI32_X1_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0 B1
MXN3 n1 A2 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN4 n1 A1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN5 n1 A0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN1 Y B0 n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN2 Y B1 n1 VPW N18_DNW L=1.8e-07 W=3.8e-07
MXP1 net59 A2 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP4 net67 A1 net59 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP5 Y A0 net67 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP3 Y B0 net55 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP2 net55 B1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT OAI32_X2_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0 B1
MXN7 n1 A2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN8 n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN9 n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNB0 Y B0 n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6 Y B1 n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXPA2 net59 A2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8 net67 A1 net59 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP9 Y A0 net67 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP7 Y B0 net55 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP6 net55 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI32_X4_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0 B1
MXN12 n1 A2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN13 n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN14 n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN14_2 n1 A0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN13_2 n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN12_2 n1 A2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN11 Y B1 n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN10 Y B0 n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN10_2 Y B0 n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN11_2 Y B1 n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP10_2 net59__2 A2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP13_2 net67__2 A1 net59__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP14_2 Y A0 net67__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP14 Y A0 net67 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP13 net67 A1 net59 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP10 net59 A2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP11_2 net55__2 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP12_2 Y B0 net55__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP12 Y B0 net55 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP11 net55 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI32_XL_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0 B1
MXN16 n1 A2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN17 n1 A1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN18 n1 A0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXNB0 Y B0 n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN15 Y B1 n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXPA2 net59 A2 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP17 net67 A1 net59 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP18 Y A0 net67 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP16 Y B0 net55 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP15 net55 B1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT OAI33_X1_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0 B1 B2
MXN4 VSS B2 n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN5 VSS B1 n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN6 VSS B0 n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN2 n1 A0 Y VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN1 n1 A1 Y VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN3 n1 A2 Y VPW N18_DNW L=1.8e-07 W=4.4e-07
MXP1 net77 B2 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP3 net73 B1 net77 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP4 Y B0 net73 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP6 Y A0 net89 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP5 net89 A1 net81 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP2 net81 A2 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT OAI33_X2_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0 B1 B2
MXN10 n1 B2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN11 n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN12 n1 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN9 Y A0 n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN7 Y A1 n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN8 Y A2 n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP7 net77 B2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP9 net73 B1 net77 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP10 Y B0 net73 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP12 Y A0 net89 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP11 net89 A1 net81 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8 net81 A2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI33_X4_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0 B1 B2
MXN16 n1 B2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN17 n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN18 n1 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN18_2 n1 B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN17_2 n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN16_2 n1 B2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN15 Y A2 n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN13 Y A1 n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN14 Y A0 n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN14_2 Y A0 n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN13_2 Y A1 n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN15_2 Y A2 n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP14_2 net77__2 B2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP15_2 net73__2 B1 net77__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP16_2 Y B0 net73__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP16 Y B0 net73 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP15 net73 B1 net77 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP14 net77 B2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP13_2 net81__2 A2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP17_2 net89__2 A1 net81__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP18_2 Y A0 net89__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP18 Y A0 net89 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP17 net89 A1 net81 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP13 net81 A2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OAI33_XL_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0 B1 B2
MXN9 n1 B2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 n1 B1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN11 n1 B0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN18 Y A0 n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 Y A1 n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 Y A2 n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXP7 net77 B2 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP8 net73 B1 net77 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP9 Y B0 net73 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP11 Y A0 net89 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP10 net89 A1 net81 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXPA2 net81 A2 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT OR2_X12_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI0_MXNA2 ny B VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI0_MXNA2_2 ny B VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI0_MXNA1_3 ny A VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI0_MXNA2_3 ny B VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA2_2 XI0_p1__2 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 ny A XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 ny A XI0_p1__3 VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI0_MXPA2_3 XI0_p1__3 B VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI0_MXPA2_4 XI0_p1__4 B VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI0_MXPA1_4 ny A XI0_p1__4 VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI0_MXPA1 ny A XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 XI0_p1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OR2_X1_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 ny B VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA1 ny A XI0_p1 VNW P18_DNW L=1.8e-07 W=6.4e-07
mXI0_MXPA2 XI0_p1 B VDD VNW P18_DNW L=1.8e-07 W=6.4e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT OR2_X2_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI0_MXNA2 ny B VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A XI0_p1 VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA2 XI0_p1 B VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OR2_X4_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA2 ny B VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA2_2 XI0_p1__2 B VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA1_2 ny A XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA1 ny A XI0_p1 VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA2 XI0_p1 B VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OR2_X6_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2 ny B VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXNA2_2 ny B VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=7e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA2_2 XI0_p1__2 B VDD VNW P18_DNW L=1.8e-07 W=1.42e-06
mXI0_MXPA1_2 ny A XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.42e-06
mXI0_MXPA1 ny A XI0_p1 VNW P18_DNW L=1.8e-07 W=1.42e-06
mXI0_MXPA2 XI0_p1 B VDD VNW P18_DNW L=1.8e-07 W=1.42e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OR2_X8_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2 ny B VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA2_2 ny B VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1_2 ny A XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 XI0_p1__2 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_3 XI0_p1__3 B VDD VNW P18_DNW L=1.8e-07 W=1.52e-06
mXI0_MXPA1_3 ny A XI0_p1__3 VNW P18_DNW L=1.8e-07 W=1.52e-06
mXI0_MXPA1 ny A XI0_p1 VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA2 XI0_p1 B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OR3_X12_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA2 ny B VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA3 ny C VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA3_2 ny C VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA2_2 ny B VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA1_3 ny A VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA2_3 ny B VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA3_3 ny C VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1_2 ny A XI0_p2__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 XI0_p2__2 B XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.86e-06
mXI0_MXPA3_2 XI0_p1__2 C VDD VNW P18_DNW L=1.8e-07 W=1.86e-06
mXI0_MXPA3_3 XI0_p1__3 C VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2_3 XI0_p2__3 B XI0_p1__3 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1_3 ny A XI0_p2__3 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1_4 ny A XI0_p2__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2_4 XI0_p2__4 B XI0_p1__4 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA3_4 XI0_p1__4 C VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA3_5 XI0_p1__5 C VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI0_MXPA2_5 XI0_p2__5 B XI0_p1__5 VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI0_MXPA1_5 ny A XI0_p2__5 VNW P18_DNW L=1.8e-07 W=1.52e-06
mXI0_MXPA1 ny A XI0_p2 VNW P18_DNW L=1.8e-07 W=1.52e-06
mXI0_MXPA2 XI0_p2 B XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3 XI0_p1 C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OR3_X1_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXNA2 ny B VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXNA3 ny C VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA1 ny A XI0_p2 VNW P18_DNW L=1.8e-07 W=7.5e-07
mXI0_MXPA2 XI0_p2 B XI0_p1 VNW P18_DNW L=1.8e-07 W=7.5e-07
mXI0_MXPA3 XI0_p1 C VDD VNW P18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT OR3_X2_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXNA2 ny B VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXNA3 ny C VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A XI0_p2 VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI0_MXPA2 XI0_p2 B XI0_p1 VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI0_MXPA3 XI0_p1 C VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OR3_X4_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA2 ny B VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA3 ny C VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA3_2 XI0_p1__2 C VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA2_2 XI0_p2__2 B XI0_p1__2 VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 ny A XI0_p2__2 VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1 ny A XI0_p2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 XI0_p2 B XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA3 XI0_p1 C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OR3_X6_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA3 ny C VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXNA2 ny B VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXNA2_2 ny B VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXNA3_2 ny C VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA3_2 XI0_p1__2 C VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI0_MXPA2_2 XI0_p2__2 B XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.61e-06
mXI0_MXPA1_2 ny A XI0_p2__2 VNW P18_DNW L=1.8e-07 W=1.61e-06
mXI0_MXPA1 ny A XI0_p2 VNW P18_DNW L=1.8e-07 W=1.61e-06
mXI0_MXPA2 XI0_p2 B XI0_p1 VNW P18_DNW L=1.8e-07 W=1.61e-06
mXI0_MXPA3 XI0_p1 C VDD VNW P18_DNW L=1.8e-07 W=1.54e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OR3_X8_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA3 ny C VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA2 ny B VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA2_2 ny B VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA3_2 ny C VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1_2 ny A XI0_p2__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 XI0_p2__2 B XI0_p1__2 VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA3_2 XI0_p1__2 C VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA3_3 XI0_p1__3 C VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2_3 XI0_p2__3 B XI0_p1__3 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1_3 ny A XI0_p2__3 VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI0_MXPA1 ny A XI0_p2 VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI0_MXPA2 XI0_p2 B XI0_p1 VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI0_MXPA3 XI0_p1 C VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OR4_X12_A7TR Y VDD VNW VPW VSS A B C D
MXNA net43 A VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXNA_2 net43 A VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXNA_3 net43 A VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXNA_4 net43 A VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXNA_5 net43 A VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXN12 net43 B VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXN12_2 net43 B VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXN12_3 net43 B VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXN12_4 net43 B VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXN12_5 net43 B VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXN13 net43 C VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXN13_2 net43 C VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXN13_3 net43 C VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXN13_4 net43 C VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXN13_5 net43 C VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXN14 net43 D VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXN14_2 net43 D VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXN14_3 net43 D VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXN14_4 net43 D VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
MXN14_5 net43 D VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
mXI0_MXNA1 Y net43 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y net43 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y net43 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y net43 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_5 Y net43 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_6 Y net43 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP22 net43 A net70 VNW P18_DNW L=1.8e-07 W=1.13e-06
MXP22_2 net43 A net70 VNW P18_DNW L=1.8e-07 W=1.13e-06
MXP22_3 net43 A net70 VNW P18_DNW L=1.8e-07 W=1.13e-06
MXP22_4 net43 A net70 VNW P18_DNW L=1.8e-07 W=1.12e-06
MXP22_5 net43 A net70 VNW P18_DNW L=1.8e-07 W=1.12e-06
MXP21 net70 B net66 VNW P18_DNW L=1.8e-07 W=1.12e-06
MXP21_2 net70 B net66 VNW P18_DNW L=1.8e-07 W=1.12e-06
MXP21_3 net70 B net66 VNW P18_DNW L=1.8e-07 W=1.13e-06
MXP21_4 net70 B net66 VNW P18_DNW L=1.8e-07 W=1.13e-06
MXP21_5 net70 B net66 VNW P18_DNW L=1.8e-07 W=1.13e-06
MXP20 net66 C net62 VNW P18_DNW L=1.8e-07 W=1.13e-06
MXP20_2 net66 C net62 VNW P18_DNW L=1.8e-07 W=1.13e-06
MXP20_3 net66 C net62 VNW P18_DNW L=1.8e-07 W=1.13e-06
MXP20_4 net66 C net62 VNW P18_DNW L=1.8e-07 W=1.12e-06
MXP20_5 net66 C net62 VNW P18_DNW L=1.8e-07 W=1.12e-06
MXP0 net62 D VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
MXP0_2 net62 D VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
MXP0_3 net62 D VDD VNW P18_DNW L=1.8e-07 W=1.13e-06
MXP0_4 net62 D VDD VNW P18_DNW L=1.8e-07 W=1.13e-06
MXP0_5 net62 D VDD VNW P18_DNW L=1.8e-07 W=1.13e-06
mXI0_MXPA1 Y net43 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y net43 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y net43 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y net43 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_5 Y net43 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_6 Y net43 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OR4_X1_A7TR Y VDD VNW VPW VSS A B C D
MXNA net43 A VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN0 net43 B VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN1 net43 C VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN2 net43 D VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXNA1 Y net43 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXP7 net43 A net70 VNW P18_DNW L=1.8e-07 W=5.9e-07
MXP6 net70 B net66 VNW P18_DNW L=1.8e-07 W=5.9e-07
MXP5 net66 C net62 VNW P18_DNW L=1.8e-07 W=5.9e-07
MXP0 net62 D VDD VNW P18_DNW L=1.8e-07 W=5.9e-07
mXI0_MXPA1 Y net43 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT OR4_X2_A7TR Y VDD VNW VPW VSS A B C D
MXNA net43 A VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN3 net43 B VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN4 net43 C VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN5 net43 D VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXNA1 Y net43 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP10 net43 A net70 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP9 net70 B net66 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP8 net66 C net62 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP0 net62 D VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPA1 Y net43 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OR4_X4_A7TR Y VDD VNW VPW VSS A B C D
MXNA net43 A VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN6 net43 B VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN7 net43 C VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN8 net43 D VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA1 Y net43 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y net43 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP0_2 net62__2 D VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
MXP11_2 net66__2 C net62__2 VNW P18_DNW L=1.8e-07 W=8.7e-07
MXP12_2 net70__2 B net66__2 VNW P18_DNW L=1.8e-07 W=8.7e-07
MXP13_2 net43 A net70__2 VNW P18_DNW L=1.8e-07 W=8.7e-07
MXP13 net43 A net70 VNW P18_DNW L=1.8e-07 W=1.01e-06
MXP12 net70 B net66 VNW P18_DNW L=1.8e-07 W=1.01e-06
MXP11 net66 C net62 VNW P18_DNW L=1.8e-07 W=1.01e-06
MXP0 net62 D VDD VNW P18_DNW L=1.8e-07 W=1.01e-06
mXI0_MXPA1 Y net43 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y net43 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OR4_X6_A7TR Y VDD VNW VPW VSS A B C D
MXN11 net43 D VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN10 net43 C VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN9 net43 B VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXNA net43 A VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXNA_2 net43 A VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN9_2 net43 B VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN10_2 net43 C VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN11_2 net43 D VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXNA1 Y net43 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y net43 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y net43 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP0_2 net62__2 D VDD VNW P18_DNW L=1.8e-07 W=1.4e-06
MXP14_2 net66__2 C net62__2 VNW P18_DNW L=1.8e-07 W=1.4e-06
MXP15_2 net70__2 B net66__2 VNW P18_DNW L=1.8e-07 W=1.4e-06
MXP16_2 net43 A net70__2 VNW P18_DNW L=1.8e-07 W=1.4e-06
MXP16 net43 A net70 VNW P18_DNW L=1.8e-07 W=1.4e-06
MXP15 net70 B net66 VNW P18_DNW L=1.8e-07 W=1.4e-06
MXP14 net66 C net62 VNW P18_DNW L=1.8e-07 W=1.4e-06
MXP0 net62 D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y net43 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y net43 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y net43 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT OR4_X8_A7TR Y VDD VNW VPW VSS A B C D
MXNA net43 A VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXNA_2 net43 A VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXNA_3 net43 A VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN12 net43 B VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN12_2 net43 B VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN12_3 net43 B VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN13 net43 C VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN13_2 net43 C VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN13_3 net43 C VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN14 net43 D VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN14_2 net43 D VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN14_3 net43 D VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI0_MXNA1 Y net43 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y net43 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y net43 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y net43 VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
MXP19 net43 A net70 VNW P18_DNW L=1.8e-07 W=1.25e-06
MXP19_2 net43 A net70 VNW P18_DNW L=1.8e-07 W=1.25e-06
MXP19_3 net43 A net70 VNW P18_DNW L=1.8e-07 W=1.25e-06
MXP18 net70 B net66 VNW P18_DNW L=1.8e-07 W=1.25e-06
MXP18_2 net70 B net66 VNW P18_DNW L=1.8e-07 W=1.25e-06
MXP18_3 net70 B net66 VNW P18_DNW L=1.8e-07 W=1.25e-06
MXP17 net66 C net62 VNW P18_DNW L=1.8e-07 W=1.25e-06
MXP17_2 net66 C net62 VNW P18_DNW L=1.8e-07 W=1.25e-06
MXP17_3 net66 C net62 VNW P18_DNW L=1.8e-07 W=1.25e-06
MXP0 net62 D VDD VNW P18_DNW L=1.8e-07 W=1.37e-06
MXP0_2 net62 D VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP0_3 net62 D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y net43 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y net43 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y net43 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y net43 VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT SDFFHQN_X1_A7TR QN VDD VNW VPW VSS CK D SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNA1 XI16_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNOE nmsi SE XI16_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI40_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
MXN1 net71 cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 m nmsi net71 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNOE m c XI6_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNA1 XI6_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=3.8e-07
mXI41_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNOE ns cn XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNA1 XI7_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPA1 XI16_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPOEN nmsi nmse XI16_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI40_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 net48 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP0 net48 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=8e-07
MX_t8 net60 c VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1 m nmsi net60 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI6_MXPOEN m cn XI6_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI6_MXPA1 XI6_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI41_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI7_MXPOEN ns c XI7_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXPA1 XI7_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT SDFFHQN_X2_A7TR QN VDD VNW VPW VSS CK D SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNA1 XI16_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNOE nmsi SE XI16_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI40_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
MXN1 net71 cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 m nmsi net71 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNOE m c XI6_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNA1 XI6_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=3.8e-07
mXI41_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNOE ns cn XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNA1 XI7_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=3.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPA1 XI16_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPOEN nmsi nmse XI16_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI40_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 net48 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP0 net48 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=8e-07
MX_t8 net60 c VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1 m nmsi net60 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI6_MXPOEN m cn XI6_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI6_MXPA1 XI6_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI41_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI7_MXPOEN ns c XI7_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXPA1 XI7_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=5.7e-07
.ends


.SUBCKT SDFFHQN_X4_A7TR QN VDD VNW VPW VSS CK D SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNA1 XI16_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNOE nmsi SE XI16_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI40_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=3.2e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=3.2e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 net71 cn VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN0 m nmsi net71 VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI6_MXNOE m c XI6_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNA1 XI6_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI41_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI7_MXNOE ns cn XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNA1 XI7_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPA1 XI16_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPOEN nmsi nmse XI16_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI40_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=4.8e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=4.8e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=9.6e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 net48 c cn VNW P18_DNW L=1.8e-07 W=7.5e-07
MX_t10 net48 CK VDD VNW P18_DNW L=1.8e-07 W=7.5e-07
MX_t8 net60 c VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
MXP1 m nmsi net60 VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI6_MXPOEN m cn XI6_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI6_MXPA1 XI6_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI41_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=9.6e-07
mXI7_MXPOEN ns c XI7_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXPA1 XI7_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFHQN_X8_A7TR QN VDD VNW VPW VSS CK D SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNA1 XI16_n1 SI VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXNOE nmsi SE XI16_n1 VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI40_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=6e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=6e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=5.2e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.3e-07
MXN0 m nmsi net71 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN1 net71 cn VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
mXI6_MXNOE m c XI6_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNA1 XI6_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=5.2e-07
mX_g5_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=5.2e-07
mXI41_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=4.7e-07
mXI41_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=4.7e-07
mXI7_MXNOE ns cn XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNA1 XI7_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=7.8e-07
mX_g2_MXNA1_2 s ns VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_3 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_4 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPA1 XI16_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI16_MXPOEN nmsi nmse XI16_p1 VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI40_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=9e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=9e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 net48 c cn VNW P18_DNW L=1.8e-07 W=9.4e-07
MX_t10 net48 CK VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP1 m nmsi net60 VNW P18_DNW L=1.8e-07 W=1.22e-06
MX_t8 net60 c VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
mXI6_MXPOEN m cn XI6_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI6_MXPA1 XI6_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g5_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI41_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI41_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI7_MXPOEN ns c XI7_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA1 XI7_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g2_MXPA1_2 s ns VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_3 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_4 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFHQ_X1_A7TR Q VDD VNW VPW VSS CK D SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNA1 XI16_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNOE nmsi SE XI16_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI72_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
MXN0 VSS CK cn VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
MXN1 net54 cn VSS VPW N18_DNW L=1.8e-07 W=4.7e-07
MX_t3 m nmsi net54 VPW N18_DNW L=1.8e-07 W=4.7e-07
mXI15_MXNOE m c XI15_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI15_MXNA1 XI15_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI41_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=5.2e-07
mXI14_MXNOE ns cn XI14_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI14_MXNA1 XI14_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPA1 XI16_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPOEN nmsi nmse XI16_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI72_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=8.8e-07
MXP1 net065 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP0 net065 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.01e-06
MX_t8 net71 c VDD VNW P18_DNW L=1.8e-07 W=7.1e-07
MXP2 m nmsi net71 VNW P18_DNW L=1.8e-07 W=7.1e-07
mXI15_MXPOEN m cn XI15_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI15_MXPA1 XI15_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.04e-06
mXI41_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.04e-06
mXI14_MXPOEN ns c XI14_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI14_MXPA1 XI14_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT SDFFHQ_X2_A7TR Q VDD VNW VPW VSS CK D SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNA1 XI16_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNOE nmsi SE XI16_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI72_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=4.8e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
MXN1 net54 cn VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MX_t3 m nmsi net54 VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI15_MXNOE m c XI15_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI15_MXNA1 XI15_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN0 VSS CK cn VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI41_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI14_MXNOE ns cn XI14_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI14_MXNA1 XI14_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPA1 XI16_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPOEN nmsi nmse XI16_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI72_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=7.2e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.25e-06
MXP2 m nmsi net71 VNW P18_DNW L=1.8e-07 W=1.01e-06
MX_t8 net71 c VDD VNW P18_DNW L=1.8e-07 W=1.01e-06
mXI15_MXPOEN m cn XI15_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI15_MXPA1 XI15_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mX_g5_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=7.5e-07
MXP1 net065 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP0 net065 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
mXI41_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.29e-06
mXI14_MXPOEN ns c XI14_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI14_MXPA1 XI14_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFHQ_X4_A7TR Q VDD VNW VPW VSS CK D SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNA1 XI16_n1 SI VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI16_MXNOE nmsi SE XI16_n1 VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI72_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=8.6e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
mX_g13_MXNA1_2 nmin D VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=7.1e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
MXN0 VSS CK cn VPW N18_DNW L=1.8e-07 W=4.6e-07
MXN1_2 net54__2 cn VSS VPW N18_DNW L=1.8e-07 W=4e-07
MX_t3_2 m nmsi net54__2 VPW N18_DNW L=1.8e-07 W=4e-07
MX_t3 m nmsi net54 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN1 net54 cn VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mXI15_MXNOE m c XI15_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI15_MXNA1 XI15_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mX_g5_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI41_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI41_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI14_MXNOE ns cn XI14_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI14_MXNA1 XI14_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPA1 XI16_p1 SI VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI16_MXPOEN nmsi nmse XI16_p1 VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI72_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
mX_g13_MXPA1_2 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=5.8e-07
MXP0 net065 c cn VNW P18_DNW L=1.8e-07 W=1.18e-06
MXP1 net065 CK VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
MX_t8_2 net71__2 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP2_2 m nmsi net71__2 VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP2 m nmsi net71 VNW P18_DNW L=1.8e-07 W=7.5e-07
MX_t8 net71 c VDD VNW P18_DNW L=1.8e-07 W=7.5e-07
mXI15_MXPOEN m cn XI15_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI15_MXPA1 XI15_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g5_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI41_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.38e-06
mXI41_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.38e-06
mXI14_MXPOEN ns c XI14_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI14_MXPA1 XI14_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFHQ_X8_A7TR Q VDD VNW VPW VSS CK D SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mXI16_MXNA1 XI16_n1 SI VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI16_MXNOE nmsi SE XI16_n1 VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI72_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI72_MXNOE_2 nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=6e-07
mXI72_MXNOE_3 nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=6e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g13_MXNA1_2 nmin D VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
MX_t3_2 m nmsi net54__2 VPW N18_DNW L=1.8e-07 W=6.3e-07
MXN1_2 net54__2 cn VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
MXN1_3 net54__3 cn VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
MX_t3_3 m nmsi net54__3 VPW N18_DNW L=1.8e-07 W=6.3e-07
MX_t3 m nmsi net54 VPW N18_DNW L=1.8e-07 W=6.9e-07
MXN1 net54 cn VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI15_MXNOE m c XI15_n1 VPW N18_DNW L=1.8e-07 W=2.9e-07
mXI15_MXNA1 XI15_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=9.1e-07
mX_g5_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=9.1e-07
mX_g5_MXNA1_3 nm m VSS VPW N18_DNW L=1.8e-07 W=9.1e-07
MXN0 VSS CK cn VPW N18_DNW L=1.8e-07 W=8.1e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
mX_g10_MXNA1_2 c nck VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
mXI41_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8.7e-07
mXI41_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=8.6e-07
mXI41_MXNOE_3 ns c nm VPW N18_DNW L=1.8e-07 W=8.6e-07
mXI14_MXNOE ns cn XI14_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI14_MXNA1 XI14_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_3 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_4 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.3e-07
mXI16_MXPA1 XI16_p1 SI VDD VNW P18_DNW L=1.8e-07 W=1.2e-06
mXI16_MXPOEN nmsi nmse XI16_p1 VNW P18_DNW L=1.8e-07 W=1.2e-06
mXI72_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=7.2e-07
mXI72_MXPOEN_2 nmsi SE nmin VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI72_MXPOEN_3 nmsi SE nmin VNW P18_DNW L=1.8e-07 W=8.7e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mX_g13_MXPA1_2 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mX_g13_MXPA1_3 nmin D VDD VNW P18_DNW L=1.8e-07 W=9.3e-07
MXP2_2 m nmsi net71__2 VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t8_2 net71__2 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t8_3 net71__3 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP2_3 m nmsi net71__3 VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP2 m nmsi net71 VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t8 net71 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mXI15_MXPOEN m cn XI15_p1 VNW P18_DNW L=1.8e-07 W=4.3e-07
mXI15_MXPA1 XI15_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.3e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g5_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g5_MXPA1_3 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g5_MXPA1_4 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP1_2 net065__2 CK VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP0_2 net065__2 c cn VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP0 net065 c cn VNW P18_DNW L=1.8e-07 W=1.19e-06
MXP1 net065 CK VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=1.03e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI41_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI41_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI41_MXPOEN_3 ns cn nm VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI14_MXPOEN ns c XI14_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI14_MXPA1 XI14_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_3 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_4 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFH_X1_A7TR Q QN VDD VNW VPW VSS CK D SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net0107 SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t20 nmsi SI net0107 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI72_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=3.8e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=3.8e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
MXN6 net104 cn VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MX_t3 m nmsi net104 VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI60_MXNOE m c XI60_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI60_MXNA1 XI60_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI65_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI14_MXNOE ns cn XI14_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI14_MXNA1 XI14_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t22 net76 nmse VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP11 nmsi SI net76 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI72_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=5.8e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=5.8e-07
MX_t10 net079 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP5 net079 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.08e-06
MX_t8 net087 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP10 m nmsi net087 VNW P18_DNW L=1.8e-07 W=7.9e-07
mXI60_MXPOEN m cn XI60_p1 VNW P18_DNW L=1.8e-07 W=3.9e-07
mXI60_MXPA1 XI60_p1 nm VDD VNW P18_DNW L=1.8e-07 W=3.9e-07
mX_g6_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI65_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI14_MXPOEN ns c XI14_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI14_MXPA1 XI14_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT SDFFH_X2_A7TR Q QN VDD VNW VPW VSS CK D SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net0107 SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t20 nmsi SI net0107 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI72_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=5e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=5e-07
MXN6 net104 cn VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
MX_t3 m nmsi net104 VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI60_MXNOE m c XI60_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI60_MXNA1 XI60_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=9.3e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=3e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=4.7e-07
mXI65_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8e-07
mXI14_MXNOE ns cn XI14_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI14_MXNA1 XI14_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t22 net76 nmse VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP11 nmsi SI net76 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI72_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
MXP10 m nmsi net087 VNW P18_DNW L=1.8e-07 W=1.01e-06
MX_t8 net087 c VDD VNW P18_DNW L=1.8e-07 W=1.01e-06
mXI60_MXPOEN m cn XI60_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI60_MXPA1 XI60_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g6_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=8.3e-07
mX_g6_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=8.3e-07
MX_t10 net079 CK VDD VNW P18_DNW L=1.8e-07 W=8.3e-07
MXP5 net079 c cn VNW P18_DNW L=1.8e-07 W=8.3e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI65_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.29e-06
mXI14_MXPOEN ns c XI14_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI14_MXPA1 XI14_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFH_X4_A7TR Q QN VDD VNW VPW VSS CK D SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net0107 SE VSS VPW N18_DNW L=1.8e-07 W=4.6e-07
MX_t20 nmsi SI net0107 VPW N18_DNW L=1.8e-07 W=4.6e-07
mXI72_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
MXN6_2 net104__2 cn VSS VPW N18_DNW L=1.8e-07 W=4e-07
MX_t3_2 m nmsi net104__2 VPW N18_DNW L=1.8e-07 W=4e-07
MX_t3 m nmsi net104 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6 net104 cn VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI60_MXNOE m c XI60_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI60_MXNA1 XI60_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=7.8e-07
mX_g6_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI65_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8e-07
mXI65_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI14_MXNOE ns cn XI14_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI14_MXNA1 XI14_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t22 net76 nmse VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
MXP11 nmsi SI net76 VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI72_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=1.21e-06
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=6.1e-07
MXP5 net079 c cn VNW P18_DNW L=1.8e-07 W=1.18e-06
MX_t10 net079 CK VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
MX_t8_2 net087__2 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP10_2 m nmsi net087__2 VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP10 m nmsi net087 VNW P18_DNW L=1.8e-07 W=7.9e-07
MX_t8 net087 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mXI60_MXPOEN m cn XI60_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI60_MXPA1 XI60_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g6_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g6_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI65_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI65_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI14_MXPOEN ns c XI14_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI14_MXPA1 XI14_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFH_X8_A7TR Q QN VDD VNW VPW VSS CK D SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN5 net0107 SE VSS VPW N18_DNW L=1.8e-07 W=8e-07
MX_t20 nmsi SI net0107 VPW N18_DNW L=1.8e-07 W=8e-07
mXI72_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=4.6e-07
mXI72_MXNOE_2 nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=8.5e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mX_g13_MXNA1_2 nmin D VSS VPW N18_DNW L=1.8e-07 W=9.3e-07
MX_t3_2 m nmsi net104__2 VPW N18_DNW L=1.8e-07 W=6.3e-07
MXN6_2 net104__2 cn VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
MXN6_3 net104__3 cn VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
MX_t3_3 m nmsi net104__3 VPW N18_DNW L=1.8e-07 W=6.3e-07
MX_t3 m nmsi net104 VPW N18_DNW L=1.8e-07 W=6.9e-07
MXN6 net104 cn VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI60_MXNOE m c XI60_n1 VPW N18_DNW L=1.8e-07 W=2.9e-07
mXI60_MXNA1 XI60_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mX_g6_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=9.1e-07
mX_g6_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=9.1e-07
mX_g6_MXNA1_3 nm m VSS VPW N18_DNW L=1.8e-07 W=9.1e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g10_MXNA1_2 c nck VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI65_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8.7e-07
mXI65_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=8.6e-07
mXI65_MXNOE_3 ns c nm VPW N18_DNW L=1.8e-07 W=8.6e-07
mXI14_MXNOE ns cn XI14_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI14_MXNA1 XI14_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_3 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_4 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
MX_t22 net76 nmse VDD VNW P18_DNW L=1.8e-07 W=1.2e-06
MXP11 nmsi SI net76 VNW P18_DNW L=1.8e-07 W=1.2e-06
mXI72_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=8.2e-07
mXI72_MXPOEN_2 nmsi SE nmin VNW P18_DNW L=1.8e-07 W=1.21e-06
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g13_MXPA1_2 nmin D VDD VNW P18_DNW L=1.8e-07 W=9.3e-07
MXP10_2 m nmsi net087__2 VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t8_2 net087__2 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t8_3 net087__3 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP10_3 m nmsi net087__3 VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP10 m nmsi net087 VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t8 net087 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mXI60_MXPOEN m cn XI60_p1 VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI60_MXPA1 XI60_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mX_g6_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g6_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g6_MXPA1_3 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g6_MXPA1_4 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t10_2 net079__2 CK VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP5_2 net079__2 c cn VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP5 net079 c cn VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t10 net079 CK VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=1.06e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI65_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI65_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI65_MXPOEN_3 ns cn nm VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI14_MXPOEN ns c XI14_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI14_MXPA1 XI14_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_3 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_4 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFNH_X1_A7TR Q QN VDD VNW VPW VSS CKN D SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 n1 SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 nmsi SI n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI53_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=4e-07
MX_t6 c CKN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 net185 CKN VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 cn net185 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN5 net58 cn VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
MX_t3 m nmsi net58 VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI7_MXNOE m c XI7_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 XI7_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI65_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI8_MXNOE ns cn XI8_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI8_MXNA1 XI8_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 p1 nmse VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9 nmsi SI p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI53_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=6e-07
MX_t10 net87 CKN VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP2 net87 cn c VNW P18_DNW L=1.8e-07 W=8e-07
mX_g14_MXPA1 net185 CKN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 cn net185 VDD VNW P18_DNW L=1.8e-07 W=8e-07
mX_g10_MXPA1_2 cn net185 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 net93 c VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
MXP10 m nmsi net93 VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI7_MXPOEN m cn XI7_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA1 XI7_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=8.9e-07
mXI65_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=8.9e-07
mXI8_MXPOEN ns c XI8_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI8_MXPA1 XI8_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT SDFFNH_X2_A7TR Q QN VDD VNW VPW VSS CKN D SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 n1 SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 nmsi SI n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI53_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=5.5e-07
MX_t6 c CKN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 net185 CKN VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
mX_g10_MXNA1 cn net185 VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
MXN5 net58 cn VSS VPW N18_DNW L=1.8e-07 W=1e-06
MX_t3 m nmsi net58 VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI7_MXNOE m c XI7_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 XI7_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI65_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8.3e-07
mXI8_MXNOE ns cn XI8_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI8_MXNA1 XI8_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 p1 nmse VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9 nmsi SI p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI53_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
MX_t10 net87 CKN VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP2 net87 cn c VNW P18_DNW L=1.8e-07 W=8e-07
mX_g14_MXPA1 net185 CKN VDD VNW P18_DNW L=1.8e-07 W=4.3e-07
mX_g10_MXPA1 cn net185 VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g10_MXPA1_2 cn net185 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 net93 c VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
MXP10 m nmsi net93 VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI7_MXPOEN m cn XI7_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA1 XI7_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.24e-06
mXI65_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI8_MXPOEN ns c XI8_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI8_MXPA1 XI8_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
.ends


.SUBCKT SDFFNH_X4_A7TR Q QN VDD VNW VPW VSS CKN D SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN4 n1 SE VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN3 nmsi SI n1 VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI53_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t6 c CKN VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXNA1 net185 CKN VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mX_g10_MXNA1 cn net185 VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
MXN5_2 net58__2 cn VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MX_t3_2 m nmsi net58__2 VPW N18_DNW L=1.8e-07 W=5.1e-07
MX_t3 m nmsi net58 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN5 net58 cn VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI7_MXNOE m c XI7_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 XI7_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=7.8e-07
mX_g5_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI65_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8e-07
mXI65_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI8_MXNOE ns cn XI8_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI8_MXNA1 XI8_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 p1 nmse VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP9 nmsi SI p1 VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI53_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=7.1e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.27e-06
MX_t10 net87 CKN VDD VNW P18_DNW L=1.8e-07 W=1e-06
MXP2 net87 cn c VNW P18_DNW L=1.8e-07 W=1e-06
mX_g14_MXPA1 net185 CKN VDD VNW P18_DNW L=1.8e-07 W=6.4e-07
mX_g10_MXPA1 cn net185 VDD VNW P18_DNW L=1.8e-07 W=1e-06
mX_g10_MXPA1_2 cn net185 VDD VNW P18_DNW L=1.8e-07 W=1e-06
MXP0_2 net93__2 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP10_2 m nmsi net93__2 VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP10 m nmsi net93 VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP0 net93 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mXI7_MXPOEN m cn XI7_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA1 XI7_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.09e-06
mX_g5_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=1.09e-06
mXI65_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.09e-06
mXI65_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.09e-06
mXI8_MXPOEN ns c XI8_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI8_MXPA1 XI8_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFNH_X8_A7TR Q QN VDD VNW VPW VSS CKN D SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 n1 SE VSS VPW N18_DNW L=1.8e-07 W=8e-07
MXN3 nmsi SI n1 VPW N18_DNW L=1.8e-07 W=8e-07
mXI53_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=8.3e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g13_MXNA1_2 nmin D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t6 c CKN VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mX_g14_MXNA1 net185 CKN VSS VPW N18_DNW L=1.8e-07 W=8.7e-07
mX_g10_MXNA1 cn net185 VSS VPW N18_DNW L=1.8e-07 W=7e-07
mX_g10_MXNA1_2 cn net185 VSS VPW N18_DNW L=1.8e-07 W=7e-07
MX_t3_2 m nmsi net58__2 VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN5_2 net58__2 cn VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN5_3 net58__3 cn VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
MX_t3_3 m nmsi net58__3 VPW N18_DNW L=1.8e-07 W=7.5e-07
MX_t3 m nmsi net58 VPW N18_DNW L=1.8e-07 W=9.8e-07
MXN5 net58 cn VSS VPW N18_DNW L=1.8e-07 W=9.8e-07
mXI7_MXNOE m c XI7_n1 VPW N18_DNW L=1.8e-07 W=4e-07
mXI7_MXNA1 XI7_n1 nm VSS VPW N18_DNW L=1.8e-07 W=4e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g5_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g5_MXNA1_3 nm m VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI65_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI65_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI65_MXNOE_3 ns c nm VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI8_MXNOE ns cn XI8_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI8_MXNA1 XI8_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_3 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_4 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 p1 nmse VDD VNW P18_DNW L=1.8e-07 W=1.2e-06
MXP9 nmsi SI p1 VNW P18_DNW L=1.8e-07 W=1.2e-06
mXI53_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=1.2e-06
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.31e-06
mX_g13_MXPA1_2 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.31e-06
MX_t10_2 net87__2 CKN VDD VNW P18_DNW L=1.8e-07 W=8.8e-07
MXP2_2 net87__2 cn c VNW P18_DNW L=1.8e-07 W=8.8e-07
MXP2 net87 cn c VNW P18_DNW L=1.8e-07 W=8.8e-07
MX_t10 net87 CKN VDD VNW P18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 net185 CKN VDD VNW P18_DNW L=1.8e-07 W=1.14e-06
mX_g10_MXPA1 cn net185 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g10_MXPA1_2 cn net185 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP10_2 m nmsi net93__2 VNW P18_DNW L=1.8e-07 W=1.22e-06
MXP0_2 net93__2 c VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
MXP0_3 net93__3 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP10_3 m nmsi net93__3 VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP10 m nmsi net93 VNW P18_DNW L=1.8e-07 W=7.6e-07
MXP0 net93 c VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI7_MXPOEN m cn XI7_p1 VNW P18_DNW L=1.8e-07 W=6e-07
mXI7_MXPA1 XI7_p1 nm VDD VNW P18_DNW L=1.8e-07 W=6e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mX_g5_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g5_MXPA1_3 nm m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI65_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI65_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI65_MXPOEN_3 ns cn nm VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI8_MXPOEN ns c XI8_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI8_MXPA1 XI8_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_3 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_4 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFNSRH_X1_A7TR Q QN VDD VNW VPW VSS CKN D RN SE SI SN
mX_g14_MXNA1 net0207 CKN VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MX_t6 c CKN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 cn net0207 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=4e-07
mXI65_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t30 nmsi SI net172 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN16 net172 SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nmset SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN18 VSS SN net163 VPW N18_DNW L=1.8e-07 W=7.3e-07
MXN17 net163 cn net160 VPW N18_DNW L=1.8e-07 W=7.3e-07
MX_t26 m nmsi net160 VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI23_MXNOE m c XI23_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI23_MXNA1 XI23_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t12 nm m net166 VPW N18_DNW L=1.8e-07 W=6.9e-07
MXN19 VSS RN net166 VPW N18_DNW L=1.8e-07 W=6.9e-07
MXN20 nm nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI81_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=5.5e-07
MXN22 ns cn net184 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN23 net184 RN net181 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN24 VSS s net181 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN21 ns nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g11_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g14_MXPA1 net0207 CKN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t4 net080 CKN VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP15 net080 cn c VNW P18_DNW L=1.8e-07 W=8e-07
mX_g10_MXPA1 cn net0207 VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=6e-07
mXI65_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP16 nmsi SI net117 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t32 net117 nmse VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nmset SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t11 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP17 m nmsi net0125 VNW P18_DNW L=1.8e-07 W=6.8e-07
MX_t24 net0125 c VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI23_MXPOEN m cn XI23_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI23_MXPA1 XI23_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 nm m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
MXP18 net111 nmset VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP19 nm RN net111 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI81_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=6.9e-07
MXP21 ns nmset net126 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP20 net126 RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP24 ns c net132 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP23 net132 nmset net135 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP22 VDD s net135 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g11_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT SDFFNSRH_X2_A7TR Q QN VDD VNW VPW VSS CKN D RN SE SI SN
mX_g14_MXNA1 net0207 CKN VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
MX_t6 c CKN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 cn net0207 VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=5.5e-07
mXI65_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t30 nmsi SI net172 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN16 net172 SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nmset SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN18 VSS SN net163 VPW N18_DNW L=1.8e-07 W=9.2e-07
MXN17 net163 cn net160 VPW N18_DNW L=1.8e-07 W=9.2e-07
MX_t26 m nmsi net160 VPW N18_DNW L=1.8e-07 W=9.2e-07
mXI23_MXNOE m c XI23_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI23_MXNA1 XI23_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t12 nm m net166 VPW N18_DNW L=1.8e-07 W=9.3e-07
MXN19 VSS RN net166 VPW N18_DNW L=1.8e-07 W=9.3e-07
MXN20 nm nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI81_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=7e-07
MXN22 ns cn net184 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN23 net184 RN net181 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN24 VSS s net181 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN21 ns nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g11_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 net0207 CKN VDD VNW P18_DNW L=1.8e-07 W=4.3e-07
MX_t4 net080 CKN VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP15 net080 cn c VNW P18_DNW L=1.8e-07 W=8e-07
mX_g10_MXPA1 cn net0207 VDD VNW P18_DNW L=1.8e-07 W=1.38e-06
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=8.3e-07
mXI65_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP16 nmsi SI net117 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t32 net117 nmse VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nmset SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t11 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP17 m nmsi net0125 VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t24 net0125 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mXI23_MXPOEN m cn XI23_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI23_MXPA1 XI23_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 nm m VDD VNW P18_DNW L=1.8e-07 W=6.2e-07
MX_t10_2 nm m VDD VNW P18_DNW L=1.8e-07 W=6.2e-07
MXP18 net111 nmset VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP19 nm RN net111 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI81_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=9.8e-07
MXP21 ns nmset net126 VNW P18_DNW L=1.8e-07 W=4.7e-07
MXP20 net126 RN VDD VNW P18_DNW L=1.8e-07 W=4.7e-07
MXP24 ns c net132 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP23 net132 nmset net135 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP22 VDD s net135 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g11_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFNSRH_X4_A7TR Q QN VDD VNW VPW VSS CKN D RN SE SI SN
mX_g14_MXNA1 net0207 CKN VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
MX_t6 c CKN VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g10_MXNA1 cn net0207 VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=9e-07
mXI65_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=4.7e-07
MX_t30 nmsi SI net172 VPW N18_DNW L=1.8e-07 W=4.7e-07
MXN16 net172 SE VSS VPW N18_DNW L=1.8e-07 W=4.7e-07
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nmset SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN18_2 VSS SN net163__2 VPW N18_DNW L=1.8e-07 W=8.6e-07
MXN17_2 net163__2 cn net160__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t26_2 m nmsi net160__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t26 m nmsi net160 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN17 net163 cn net160 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN18 VSS SN net163 VPW N18_DNW L=1.8e-07 W=8.4e-07
mXI23_MXNOE m c XI23_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI23_MXNA1 XI23_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN19_2 VSS RN net166__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t12_2 nm m net166__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t12 nm m net166 VPW N18_DNW L=1.8e-07 W=7.6e-07
MXN19 VSS RN net166 VPW N18_DNW L=1.8e-07 W=7.6e-07
MXN20 nm nmset VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
mXI81_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN22 ns cn net184 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN23 net184 RN net181 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN24 VSS s net181 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN21 ns nmset VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
mX_g11_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 net0207 CKN VDD VNW P18_DNW L=1.8e-07 W=6.4e-07
MX_t4 net080 CKN VDD VNW P18_DNW L=1.8e-07 W=1e-06
MXP15 net080 cn c VNW P18_DNW L=1.8e-07 W=1e-06
mX_g10_MXPA1 cn net0207 VDD VNW P18_DNW L=1.8e-07 W=1.11e-06
mX_g10_MXPA1_2 cn net0207 VDD VNW P18_DNW L=1.8e-07 W=1.11e-06
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI65_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=7.1e-07
MXP16 nmsi SI net117 VNW P18_DNW L=1.8e-07 W=7.1e-07
MX_t32 net117 nmse VDD VNW P18_DNW L=1.8e-07 W=7.1e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nmset SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t11 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t24_2 net0125__2 c VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP17_2 m nmsi net0125__2 VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP17 m nmsi net0125 VNW P18_DNW L=1.8e-07 W=4.9e-07
MX_t24 net0125 c VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
mXI23_MXPA1 XI23_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI23_MXPOEN m cn XI23_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 nm m VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MX_t10_2 nm m VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP18 net111 nmset VDD VNW P18_DNW L=1.8e-07 W=5.5e-07
MXP19 nm RN net111 VNW P18_DNW L=1.8e-07 W=5.5e-07
mXI81_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=4.1e-07
mXI81_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.2e-06
MXP20 net126 RN VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
MXP21 ns nmset net126 VNW P18_DNW L=1.8e-07 W=8.7e-07
MXP24 ns c net132 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP23 net132 nmset net135 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP22 VDD s net135 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g11_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.29e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFNSRH_X8_A7TR Q QN VDD VNW VPW VSS CKN D RN SE SI SN
mX_g14_MXNA1 net0207 CKN VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
MX_t6 c CKN VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g10_MXNA1 cn net0207 VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=9e-07
mXI65_MXNOE nmsi nmse nmin VPW N18_DNW L=1.8e-07 W=4.7e-07
MX_t30 nmsi SI net172 VPW N18_DNW L=1.8e-07 W=4.7e-07
MXN16 net172 SE VSS VPW N18_DNW L=1.8e-07 W=4.7e-07
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nmset SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN18_2 VSS SN net163__2 VPW N18_DNW L=1.8e-07 W=8.6e-07
MXN17_2 net163__2 cn net160__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t26_2 m nmsi net160__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t26 m nmsi net160 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN17 net163 cn net160 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN18 VSS SN net163 VPW N18_DNW L=1.8e-07 W=8.4e-07
mXI23_MXNOE m c XI23_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI23_MXNA1 XI23_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN19_2 VSS RN net166__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t12_2 nm m net166__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t12 nm m net166 VPW N18_DNW L=1.8e-07 W=7.6e-07
MXN19 VSS RN net166 VPW N18_DNW L=1.8e-07 W=7.6e-07
MXN20 nm nmset VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
mXI81_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN22 ns cn net184 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN23 net184 RN net181 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN24 VSS s net181 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN21 ns nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g11_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_3 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_4 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 net0207 CKN VDD VNW P18_DNW L=1.8e-07 W=6.4e-07
MX_t4 net080 CKN VDD VNW P18_DNW L=1.8e-07 W=1e-06
MXP15 net080 cn c VNW P18_DNW L=1.8e-07 W=1e-06
mX_g10_MXPA1 cn net0207 VDD VNW P18_DNW L=1.8e-07 W=1.11e-06
mX_g10_MXPA1_2 cn net0207 VDD VNW P18_DNW L=1.8e-07 W=1.11e-06
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.29e-06
mXI65_MXPOEN nmsi SE nmin VNW P18_DNW L=1.8e-07 W=7.1e-07
MXP16 nmsi SI net117 VNW P18_DNW L=1.8e-07 W=7.1e-07
MX_t32 net117 nmse VDD VNW P18_DNW L=1.8e-07 W=7.1e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nmset SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t11 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t24_2 net0125__2 c VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP17_2 m nmsi net0125__2 VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP17 m nmsi net0125 VNW P18_DNW L=1.8e-07 W=4.9e-07
MX_t24 net0125 c VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
mXI23_MXPA1 XI23_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI23_MXPOEN m cn XI23_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 nm m VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MX_t10_2 nm m VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP18 net111 nmset VDD VNW P18_DNW L=1.8e-07 W=5.5e-07
MXP19 nm RN net111 VNW P18_DNW L=1.8e-07 W=5.5e-07
mXI81_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=4.1e-07
mXI81_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.2e-06
MXP20 net126 RN VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP21 ns nmset net126 VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP24 ns c net132 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP23 net132 nmset net135 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP22 VDD s net135 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g11_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_3 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_4 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFQN_X1_A7TR QN VDD VNW VPW VSS CK D SE SI
mX_g8_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net108 SE net129 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN11 VSS SI net108 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 net111 nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net129 D net111 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t1 nm cn net129 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNOE nm c XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 XI1_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNOE ns c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI2_MXNOE ns cn XI2_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI2_MXNA1 XI2_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g8_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 net69 nmse net65 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t8 net65 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 net68 SE VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP4 net69 D net68 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP5 nm c net69 VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI1_MXPOEN nm cn XI1_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 XI1_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI0_MXPA1 XI0_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPOEN ns cn XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI2_MXPOEN ns c XI2_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI2_MXPA1 XI2_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT SDFFQN_X2_A7TR QN VDD VNW VPW VSS CK D SE SI
mX_g8_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net108 SE net129 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN11 VSS SI net108 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 net111 nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net129 D net111 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t1 nm cn net129 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNOE nm c XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 XI1_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNOE ns c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI2_MXNOE ns cn XI2_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI2_MXNA1 XI2_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g8_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 net69 nmse net65 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t8 net65 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 net68 SE VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP4 net69 D net68 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP5 nm c net69 VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI1_MXPOEN nm cn XI1_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 XI1_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI0_MXPA1 XI0_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPOEN ns cn XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI2_MXPOEN ns c XI2_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI2_MXPA1 XI2_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.29e-06
.ends


.SUBCKT SDFFQN_X4_A7TR QN VDD VNW VPW VSS CK D SE SI
mX_g8_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net108 SE net129 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN11 VSS SI net108 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 net111 nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net129 D net111 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t1 nm cn net129 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNOE nm c XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 XI1_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNOE ns c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI2_MXNOE ns cn XI2_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI2_MXNA1 XI2_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g8_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 net69 nmse net65 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t8 net65 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 net68 SE VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP4 net69 D net68 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP5 nm c net69 VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI1_MXPOEN nm cn XI1_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 XI1_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI0_MXPA1 XI0_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPOEN ns cn XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI2_MXPOEN ns c XI2_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI2_MXPA1 XI2_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g9_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFQ_X1_A7TR Q VDD VNW VPW VSS CK D SE SI
mX_g8_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net064 SE net055 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 VSS SI net064 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 net059 nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 net055 D net059 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 nm cn net055 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNOE nm c XI16_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNA1 XI16_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 net105 m VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MX_t12 ns c net105 VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI15_MXNOE ns cn XI15_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI15_MXNA1 XI15_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g9_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g8_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 net076 nmse net070 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 net070 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net074 SE VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP4 net076 D net074 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP3 nm c net076 VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI16_MXPOEN nm cn XI16_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPA1 XI16_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
MX_t14 net80 m VDD VNW P18_DNW L=1.8e-07 W=6.2e-07
MXP7 ns cn net80 VNW P18_DNW L=1.8e-07 W=6.2e-07
mXI15_MXPOEN ns c XI15_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI15_MXPA1 XI15_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g9_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT SDFFQ_X2_A7TR Q VDD VNW VPW VSS CK D SE SI
mX_g8_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net064 SE net055 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 VSS SI net064 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 net059 nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 net055 D net059 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 nm cn net055 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNOE nm c XI16_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNA1 XI16_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 net105 m VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
MX_t12 ns c net105 VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI15_MXNOE ns cn XI15_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI15_MXNA1 XI15_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g9_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g8_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 net076 nmse net070 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 net070 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net074 SE VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP4 net076 D net074 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP3 nm c net076 VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI16_MXPOEN nm cn XI16_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPA1 XI16_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
MX_t14 net80 m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
MXP7 ns cn net80 VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI15_MXPOEN ns c XI15_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI15_MXPA1 XI15_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g9_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.29e-06
.ends


.SUBCKT SDFFQ_X4_A7TR Q VDD VNW VPW VSS CK D SE SI
mX_g8_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net064 SE net055 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 VSS SI net064 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 net059 nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 net055 D net059 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 nm cn net055 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNOE nm c XI16_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNA1 XI16_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=3.2e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 net105 m VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t12 ns c net105 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI15_MXNOE ns cn XI15_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI15_MXNA1 XI15_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g9_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g8_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 net076 nmse net070 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 net070 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net074 SE VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP4 net076 D net074 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP3 nm c net076 VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI16_MXPOEN nm cn XI16_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPA1 XI16_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
mX_g14_MXPA1_2 cn CK VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
MX_t14 net80 m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
MXP7 ns cn net80 VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI15_MXPOEN ns c XI15_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI15_MXPA1 XI15_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g9_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mX_g9_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFRHQ_X1_A7TR Q VDD VNW VPW VSS CK D RN SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 XI1_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNOE nmsi SE XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI58_MXNOE nmsi nmse wlnmin VPW N18_DNW L=1.8e-07 W=3.6e-07
mX_g13_MXNA1 wlnmin D VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
MXN9 n1 cn VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN3 m nmsi n1 VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXNOE m c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t11 nm m net128 VPW N18_DNW L=1.8e-07 W=7.1e-07
MXN6 VSS RN net128 VPW N18_DNW L=1.8e-07 W=7.1e-07
mXI81_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=5.2e-07
MX_t18 ns cn net149 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN7 net149 RN net146 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN8 VSS s net146 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI26_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 XI1_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPOEN nmsi nmse XI1_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI58_MXPOEN nmsi SE wlnmin VNW P18_DNW L=1.8e-07 W=5.4e-07
mX_g13_MXPA1 wlnmin D VDD VNW P18_DNW L=1.8e-07 W=9.3e-07
MX_t4 net065 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP8 net065 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.03e-06
MXP11 p1 c VDD VNW P18_DNW L=1.8e-07 W=7.5e-07
MXP13 m nmsi p1 VNW P18_DNW L=1.8e-07 W=7.5e-07
mXI0_MXPOEN m cn XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 XI0_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 nm m VDD VNW P18_DNW L=1.8e-07 W=1.01e-06
MX_t7 nm RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI81_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.04e-06
MXP10 ns c net109 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9 VDD s net109 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t15 ns RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI26_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT SDFFRHQ_X2_A7TR Q VDD VNW VPW VSS CK D RN SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 XI1_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNOE nmsi SE XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI58_MXNOE nmsi nmse wlnmin VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g13_MXNA1 wlnmin D VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN9 n1 cn VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
MXN3 m nmsi n1 VPW N18_DNW L=1.8e-07 W=6.1e-07
mXI0_MXNOE m c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6_2 VSS RN net128__2 VPW N18_DNW L=1.8e-07 W=4.9e-07
MX_t11_2 nm m net128__2 VPW N18_DNW L=1.8e-07 W=4.9e-07
MX_t11 nm m net128 VPW N18_DNW L=1.8e-07 W=4.9e-07
MXN6 VSS RN net128 VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI81_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI81_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t18 ns cn net149 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN7 net149 RN net146 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN8 VSS s net146 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI26_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 XI1_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPOEN nmsi nmse XI1_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI58_MXPOEN nmsi SE wlnmin VNW P18_DNW L=1.8e-07 W=7.6e-07
mX_g13_MXPA1 wlnmin D VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
MX_t4 net065 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP8 net065 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.25e-06
MXP11 p1 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP13 m nmsi p1 VNW P18_DNW L=1.8e-07 W=9.2e-07
mXI0_MXPOEN m cn XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 XI0_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 nm m VDD VNW P18_DNW L=1.8e-07 W=7.5e-07
MX_t10_2 nm m VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
MX_t7 nm RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI81_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=7.7e-07
mXI81_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=7.4e-07
MXP10 ns c net109 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9 VDD s net109 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t15 ns RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI26_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFRHQ_X4_A7TR Q VDD VNW VPW VSS CK D RN SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 XI1_n1 SI VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI1_MXNOE nmsi SE XI1_n1 VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI58_MXNOE nmsi nmse wlnmin VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g13_MXNA1 wlnmin D VSS VPW N18_DNW L=1.8e-07 W=4.6e-07
mX_g13_MXNA1_2 wlnmin D VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=4.6e-07
MXN9_2 n1__2 cn VSS VPW N18_DNW L=1.8e-07 W=4e-07
MXN3_2 m nmsi n1__2 VPW N18_DNW L=1.8e-07 W=4e-07
MXN3 m nmsi n1 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN9 n1 cn VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mXI0_MXNOE m c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6_2 VSS RN net128__2 VPW N18_DNW L=1.8e-07 W=7.4e-07
MX_t11_2 nm m net128__2 VPW N18_DNW L=1.8e-07 W=7.4e-07
MX_t11 nm m net128 VPW N18_DNW L=1.8e-07 W=7.4e-07
MXN6 VSS RN net128 VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI81_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI81_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=5.3e-07
MX_t18 ns cn net149 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN7 net149 RN net146 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN8 VSS s net146 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI26_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
mX_g3_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 XI1_p1 SI VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI1_MXPOEN nmsi nmse XI1_p1 VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI58_MXPOEN nmsi SE wlnmin VNW P18_DNW L=1.8e-07 W=1.06e-06
mX_g13_MXPA1 wlnmin D VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
mX_g13_MXPA1_2 wlnmin D VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=1.07e-06
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=5.9e-07
MXP8 net065 c cn VNW P18_DNW L=1.8e-07 W=1.18e-06
MX_t4 net065 CK VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
MXP11_2 p1__2 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP13_2 m nmsi p1__2 VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP13 m nmsi p1 VNW P18_DNW L=1.8e-07 W=7.5e-07
MXP11 p1 c VDD VNW P18_DNW L=1.8e-07 W=7.5e-07
mXI0_MXPOEN m cn XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 XI0_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 nm m VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
MX_t10_2 nm m VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MX_t7 nm RN VDD VNW P18_DNW L=1.8e-07 W=6.9e-07
mXI81_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.05e-06
mXI81_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.05e-06
MXP10 ns c net109 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9 VDD s net109 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t15 ns RN VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI26_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFRHQ_X8_A7TR Q VDD VNW VPW VSS CK D RN SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI1_MXNA1 XI1_n1 SI VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI1_MXNOE nmsi SE XI1_n1 VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI58_MXNOE nmsi nmse wlnmin VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI58_MXNOE_2 nmsi nmse wlnmin VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI58_MXNOE_3 nmsi nmse wlnmin VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g13_MXNA1 wlnmin D VSS VPW N18_DNW L=1.8e-07 W=8.6e-07
mX_g13_MXNA1_2 wlnmin D VSS VPW N18_DNW L=1.8e-07 W=8.6e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g10_MXNA1_2 c nck VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN3_2 m nmsi n1__2 VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN9_2 n1__2 cn VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN9_3 n1__3 cn VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN3_3 m nmsi n1__3 VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN3 m nmsi n1 VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN9 n1 cn VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI0_MXNOE m c XI0_n1 VPW N18_DNW L=1.8e-07 W=3e-07
mXI0_MXNA1 XI0_n1 nm VSS VPW N18_DNW L=1.8e-07 W=3e-07
MX_t11_2 nm m net128__2 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN6_2 VSS RN net128__2 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN6_3 VSS RN net128__3 VPW N18_DNW L=1.8e-07 W=8.1e-07
MX_t11_3 nm m net128__3 VPW N18_DNW L=1.8e-07 W=8.1e-07
MX_t11 nm m net128 VPW N18_DNW L=1.8e-07 W=7.3e-07
MXN6 VSS RN net128 VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI81_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI81_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI81_MXNOE_3 ns c nm VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI81_MXNOE_4 ns c nm VPW N18_DNW L=1.8e-07 W=4.9e-07
MX_t18 ns cn net149 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN7 net149 RN net146 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN8 VSS s net146 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI26_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mX_g3_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1_3 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1_4 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI1_MXPA1 XI1_p1 SI VDD VNW P18_DNW L=1.8e-07 W=1.2e-06
mXI1_MXPOEN nmsi nmse XI1_p1 VNW P18_DNW L=1.8e-07 W=1.2e-06
mXI58_MXPOEN nmsi SE wlnmin VNW P18_DNW L=1.8e-07 W=7.2e-07
mXI58_MXPOEN_2 nmsi SE wlnmin VNW P18_DNW L=1.8e-07 W=9.3e-07
mXI58_MXPOEN_3 nmsi SE wlnmin VNW P18_DNW L=1.8e-07 W=9.3e-07
mX_g13_MXPA1 wlnmin D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g13_MXPA1_2 wlnmin D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g13_MXPA1_3 wlnmin D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=1.06e-06
MX_t4_2 net065__2 CK VDD VNW P18_DNW L=1.8e-07 W=1.17e-06
MXP8_2 net065__2 c cn VNW P18_DNW L=1.8e-07 W=1.17e-06
MXP8 net065 c cn VNW P18_DNW L=1.8e-07 W=1.17e-06
MX_t4 net065 CK VDD VNW P18_DNW L=1.8e-07 W=1.17e-06
MXP13_2 m nmsi p1__2 VNW P18_DNW L=1.8e-07 W=1.22e-06
MXP11_2 p1__2 c VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
MXP11_3 p1__3 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP13_3 m nmsi p1__3 VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP13 m nmsi p1 VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP11 p1 c VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
mXI0_MXPOEN m cn XI0_p1 VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI0_MXPA1 XI0_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
MX_t10 nm m VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
MX_t10_2 nm m VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
MX_t10_3 nm m VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
MX_t10_4 nm m VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
MX_t7 nm RN VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI81_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI81_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI81_MXPOEN_3 ns cn nm VNW P18_DNW L=1.8e-07 W=1.08e-06
mXI81_MXPOEN_4 ns cn nm VNW P18_DNW L=1.8e-07 W=1.08e-06
MXP10 ns c net109 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9 VDD s net109 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t15 ns RN VDD VNW P18_DNW L=1.8e-07 W=6.6e-07
MX_t15_2 ns RN VDD VNW P18_DNW L=1.8e-07 W=6.6e-07
mXI26_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_3 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_4 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFRQ_X1_A7TR Q VDD VNW VPW VSS CK D RN SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 net130 D net_clr_ VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t7 nmrs nmse net130 VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t3 nmrs SE net138 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 net138 SI net_clr_ VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t9 net_clr_ RN VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI76_MXNOE nm cn nmrs VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 nm c net123 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net118 m net123 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 net118 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI81_MXNOE s c m VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXNOE s cn XI0_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXNA1 XI0_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA2 XI1_n1 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 ns s XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t5 net97 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP2 nmrs SE net97 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP1 nmrs nmse net105 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t1 net105 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP3 nm RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI76_MXPOEN nm c nmrs VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 nm cn net89 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP7 VDD m net89 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g6_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI81_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPOEN s c XI0_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXPA1 XI0_p1 ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXPA2 ns RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT SDFFRQ_X2_A7TR Q VDD VNW VPW VSS CK D RN SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 net130 D net_clr_ VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t7 nmrs nmse net130 VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t3 nmrs SE net138 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 net138 SI net_clr_ VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t9 net_clr_ RN VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI76_MXNOE nm cn nmrs VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 nm c net123 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net118 m net123 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 net118 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI81_MXNOE s c m VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXNOE s cn XI0_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXNA1 XI0_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA2 XI1_n1 RN VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI1_MXNA1 ns s XI1_n1 VPW N18_DNW L=1.8e-07 W=3.7e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t5 net97 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP2 nmrs SE net97 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP1 nmrs nmse net105 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t1 net105 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP3 nm RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI76_MXPOEN nm c nmrs VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 nm cn net89 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP7 VDD m net89 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g6_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI81_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPOEN s c XI0_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXPA1 XI0_p1 ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXPA2 ns RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFRQ_X4_A7TR Q VDD VNW VPW VSS CK D RN SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 net130 D net_clr_ VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t7 nmrs nmse net130 VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t3 nmrs SE net138 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 net138 SI net_clr_ VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t9 net_clr_ RN VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI76_MXNOE nm cn nmrs VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 nm c net123 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net118 m net123 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 net118 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI81_MXNOE s c m VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXNOE s cn XI0_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXNA1 XI0_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA2 XI1_n1 RN VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXNA1 ns s XI1_n1 VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t5 net97 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP2 nmrs SE net97 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP1 nmrs nmse net105 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t1 net105 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP3 nm RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI76_MXPOEN nm c nmrs VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 nm cn net89 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP7 VDD m net89 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g6_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI81_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPOEN s c XI0_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXPA1 XI0_p1 ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXPA2 ns RN VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFR_X1_A7TR Q QN VDD VNW VPW VSS CK D RN SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net104 D net_clr_ VPW N18_DNW L=1.8e-07 W=3.7e-07
MXN9 nmrs nmse net104 VPW N18_DNW L=1.8e-07 W=3.7e-07
MXN7 nmrs SE net77 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net77 SI net_clr_ VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN11 net_clr_ RN VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI70_MXNOE nm cn nmrs VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN12 nm c net89 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN13 net83 m net89 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN14 net83 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI81_MXNOE s c m VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXNOE s cn XI0_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXNA1 XI0_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 XI1_n1 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 ns s XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9 net139 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP10 nmrs SE net139 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP8 nmrs nmse net115 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP7 net115 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP3 nm RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI70_MXPOEN nm c nmrs VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP11 nm cn net124 VNW P18_DNW L=1.8e-07 W=2.2e-07
MXP12 VDD m net124 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g6_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=8.3e-07
mXI81_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=8.3e-07
mXI0_MXPOEN s c XI0_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXPA1 XI0_p1 ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXPA2 ns RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT SDFFR_X2_A7TR Q QN VDD VNW VPW VSS CK D RN SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net104 D net_clr_ VPW N18_DNW L=1.8e-07 W=3.7e-07
MXN9 nmrs nmse net104 VPW N18_DNW L=1.8e-07 W=3.7e-07
MXN7 nmrs SE net77 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net77 SI net_clr_ VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN11 net_clr_ RN VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI70_MXNOE nm cn nmrs VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN12 nm c net89 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN13 net83 m net89 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN14 net83 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI81_MXNOE s c m VPW N18_DNW L=1.8e-07 W=6e-07
mXI0_MXNOE s cn XI0_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXNA1 XI0_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA2 XI1_n1 RN VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI1_MXNA1 ns s XI1_n1 VPW N18_DNW L=1.8e-07 W=3.7e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9 net139 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP10 nmrs SE net139 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP8 nmrs nmse net115 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP7 net115 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP3 nm RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=8.3e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI70_MXPOEN nm c nmrs VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP11 nm cn net124 VNW P18_DNW L=1.8e-07 W=2.2e-07
MXP12 VDD m net124 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g6_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
mXI81_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=1.2e-06
mXI0_MXPOEN s c XI0_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXPA1 XI0_p1 ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXPA2 ns RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFR_X4_A7TR Q QN VDD VNW VPW VSS CK D RN SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net104 D net_clr_ VPW N18_DNW L=1.8e-07 W=6.9e-07
MXN9 nmrs nmse net104 VPW N18_DNW L=1.8e-07 W=6.9e-07
MXN7 nmrs SE net77 VPW N18_DNW L=1.8e-07 W=3.4e-07
MXN8 net77 SI net_clr_ VPW N18_DNW L=1.8e-07 W=3.4e-07
MXN11 net_clr_ RN VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI70_MXNOE nm cn nmrs VPW N18_DNW L=1.8e-07 W=5.2e-07
MXN12 nm c net89 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN13 net83 m net89 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN14 net83 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI81_MXNOE s c m VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI0_MXNOE s cn XI0_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXNA1 XI0_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA2 XI1_n1 RN VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI1_MXNA1 ns s XI1_n1 VPW N18_DNW L=1.8e-07 W=6.6e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9 net139 D VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP10 nmrs SE net139 VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP8 nmrs nmse net115 VNW P18_DNW L=1.8e-07 W=5.2e-07
MXP7 net115 SI VDD VNW P18_DNW L=1.8e-07 W=5.2e-07
MXP3 nm RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI70_MXPOEN nm c nmrs VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP11 nm cn net124 VNW P18_DNW L=1.8e-07 W=2.2e-07
MXP12 VDD m net124 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g6_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
mXI81_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=1.25e-06
mXI0_MXPOEN s c XI0_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXPA1 XI0_p1 ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXPA2 ns RN VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFSHQ_X1_A7TR Q VDD VNW VPW VSS CK D SE SI SN
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
mX_g13_MXNA1 wlnmin D VSS VPW N18_DNW L=1.8e-07 W=3.8e-07
mXI76_MXNOE nmsi nmse wlnmin VPW N18_DNW L=1.8e-07 W=3.8e-07
mXI1_MXNOE nmsi SE XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 XI1_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nmset_ SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net0112 SN VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
MXN3 net169 cn net0112 VPW N18_DNW L=1.8e-07 W=6.7e-07
MX_t11 m nmsi net169 VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI13_MXNOE m c XI13_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNA1 XI13_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI81_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=5.5e-07
MXN5 ns cn net160 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 VSS s net160 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 ns nmset_ VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t4 net088 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP3 net088 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.01e-06
mX_g13_MXPA1 wlnmin D VDD VNW P18_DNW L=1.8e-07 W=5.8e-07
mXI76_MXPOEN nmsi SE wlnmin VNW P18_DNW L=1.8e-07 W=5.8e-07
mXI1_MXPOEN nmsi nmse XI1_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 XI1_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nmset_ SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 VDD SN m VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 m nmsi net56 VNW P18_DNW L=1.8e-07 W=6.8e-07
MX_t8 net56 c VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI13_MXPA1 XI13_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPOEN m cn XI13_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=5.5e-07
mX_g7_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=5.5e-07
mXI81_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.1e-06
MXP7 net72 c ns VNW P18_DNW L=1.8e-07 W=2.2e-07
MXP6 net75 nmset_ net72 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 net75 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT SDFFSHQ_X2_A7TR Q VDD VNW VPW VSS CK D SE SI SN
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.1e-07
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mX_g13_MXNA1 wlnmin D VSS VPW N18_DNW L=1.8e-07 W=4.6e-07
mXI76_MXNOE nmsi nmse wlnmin VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI1_MXNOE nmsi SE XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 XI1_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nmset_ SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net0112 SN VSS VPW N18_DNW L=1.8e-07 W=9.3e-07
MXN3 net169 cn net0112 VPW N18_DNW L=1.8e-07 W=9.3e-07
MX_t11 m nmsi net169 VPW N18_DNW L=1.8e-07 W=9.3e-07
mXI13_MXNOE m c XI13_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNA1 XI13_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=8.9e-07
mXI81_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=7.9e-07
MXN5 ns cn net160 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 VSS s net160 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 ns nmset_ VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t4 net088 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP3 net088 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.25e-06
mX_g13_MXPA1 wlnmin D VDD VNW P18_DNW L=1.8e-07 W=8.1e-07
mXI76_MXPOEN nmsi SE wlnmin VNW P18_DNW L=1.8e-07 W=8.1e-07
mXI1_MXPOEN nmsi nmse XI1_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 XI1_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nmset_ SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 VDD SN m VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 m nmsi net56 VNW P18_DNW L=1.8e-07 W=9e-07
MX_t8 net56 c VDD VNW P18_DNW L=1.8e-07 W=9e-07
mXI13_MXPA1 XI13_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPOEN m cn XI13_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
mX_g7_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=9.7e-07
mXI81_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.57e-06
MXP7 net72 c ns VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 net75 nmset_ net72 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 net75 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFSHQ_X4_A7TR Q VDD VNW VPW VSS CK D SE SI SN
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=7.2e-07
mX_g13_MXNA1 wlnmin D VSS VPW N18_DNW L=1.8e-07 W=9e-07
mXI76_MXNOE nmsi nmse wlnmin VPW N18_DNW L=1.8e-07 W=8.4e-07
mXI1_MXNOE nmsi SE XI1_n1 VPW N18_DNW L=1.8e-07 W=3.3e-07
mXI1_MXNA1 XI1_n1 SI VSS VPW N18_DNW L=1.8e-07 W=3.3e-07
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nmset_ SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4_2 net0112__2 SN VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
MXN3_2 net169__2 cn net0112__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t11_2 m nmsi net169__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t11 m nmsi net169 VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN3 net169 cn net0112 VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN4 net0112 SN VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI13_MXNOE m c XI13_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNA1 XI13_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mX_g7_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI81_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=1.26e-06
MXN5 ns cn net160 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN6 VSS s net160 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 ns nmset_ VSS VPW N18_DNW L=1.8e-07 W=2.5e-07
MXN7_2 ns nmset_ VSS VPW N18_DNW L=1.8e-07 W=2.5e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=5.9e-07
MX_t4 net088 CK VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP3 net088 c cn VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=9.5e-07
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=9.5e-07
mX_g13_MXPA1 wlnmin D VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI76_MXPOEN nmsi SE wlnmin VNW P18_DNW L=1.8e-07 W=1.17e-06
mXI1_MXPOEN nmsi nmse XI1_p1 VNW P18_DNW L=1.8e-07 W=5e-07
mXI1_MXPA1 XI1_p1 SI VDD VNW P18_DNW L=1.8e-07 W=5e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nmset_ SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 VDD SN m VNW P18_DNW L=1.8e-07 W=6.5e-07
MX_t8_2 net56__2 c VDD VNW P18_DNW L=1.8e-07 W=8.4e-07
MXP4_2 m nmsi net56__2 VNW P18_DNW L=1.8e-07 W=8.4e-07
MXP4 m nmsi net56 VNW P18_DNW L=1.8e-07 W=8.4e-07
MX_t8 net56 c VDD VNW P18_DNW L=1.8e-07 W=8.4e-07
mXI13_MXPA1 XI13_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPOEN m cn XI13_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
mX_g7_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
mX_g7_MXPA1_3 nm m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI81_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.03e-06
mXI81_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.2e-06
MXP7 net72 c ns VNW P18_DNW L=1.8e-07 W=2.2e-07
MXP6 net75 nmset_ net72 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 net75 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFSHQ_X8_A7TR Q VDD VNW VPW VSS CK D SE SI SN
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=7.2e-07
mX_g13_MXNA1 wlnmin D VSS VPW N18_DNW L=1.8e-07 W=9e-07
mXI76_MXNOE nmsi nmse wlnmin VPW N18_DNW L=1.8e-07 W=8.4e-07
mXI1_MXNOE nmsi SE XI1_n1 VPW N18_DNW L=1.8e-07 W=3.3e-07
mXI1_MXNA1 XI1_n1 SI VSS VPW N18_DNW L=1.8e-07 W=3.3e-07
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nmset_ SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4_2 net0112__2 SN VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
MXN3_2 net169__2 cn net0112__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t11_2 m nmsi net169__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t11 m nmsi net169 VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN3 net169 cn net0112 VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN4 net0112 SN VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI13_MXNOE m c XI13_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNA1 XI13_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mX_g7_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI81_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=1.26e-06
MXN5 ns cn net160 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN6 VSS s net160 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 ns nmset_ VSS VPW N18_DNW L=1.8e-07 W=2.5e-07
MXN7_2 ns nmset_ VSS VPW N18_DNW L=1.8e-07 W=2.5e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1_3 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1_4 Q ns VSS VPW N18_DNW L=1.8e-07 W=5.2e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=5.9e-07
MX_t4 net088 CK VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP3 net088 c cn VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=9.5e-07
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=9.5e-07
mX_g13_MXPA1 wlnmin D VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI76_MXPOEN nmsi SE wlnmin VNW P18_DNW L=1.8e-07 W=1.17e-06
mXI1_MXPOEN nmsi nmse XI1_p1 VNW P18_DNW L=1.8e-07 W=5e-07
mXI1_MXPA1 XI1_p1 SI VDD VNW P18_DNW L=1.8e-07 W=5e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nmset_ SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 VDD SN m VNW P18_DNW L=1.8e-07 W=6.5e-07
MX_t8_2 net56__2 c VDD VNW P18_DNW L=1.8e-07 W=8.4e-07
MXP4_2 m nmsi net56__2 VNW P18_DNW L=1.8e-07 W=8.4e-07
MXP4 m nmsi net56 VNW P18_DNW L=1.8e-07 W=8.4e-07
MX_t8 net56 c VDD VNW P18_DNW L=1.8e-07 W=8.4e-07
mXI13_MXPA1 XI13_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPOEN m cn XI13_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
mX_g7_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
mX_g7_MXPA1_3 nm m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI81_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.03e-06
mXI81_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.2e-06
MXP7 net72 c ns VNW P18_DNW L=1.8e-07 W=2.2e-07
MXP6 net75 nmset_ net72 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 net75 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_3 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_4 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT SDFFSQ_X1_A7TR Q VDD VNW VPW VSS CK D SE SI SN
mX_g8_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net123 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 nmrs nmse net123 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t6 nmrs SE net150 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net150 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI57_MXNOE nm cn nmrs VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNOE nm c XI7_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 XI7_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t13 m nm NSN VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI81_MXNOE s c m VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN11 s cn net141 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN12 NSN ns net141 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t14 NSN SN VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g8_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t7 net83 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP10 nmrs SE net83 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP9 net113 nmse nmrs VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 VDD SI net113 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI57_MXPOEN nm c nmrs VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPOEN nm cn XI7_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA1 XI7_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP11 VDD nm m VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI81_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP12 VDD SN m VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP13 VDD SN s VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP14 net107 c s VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP15 net107 ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT SDFFSQ_X2_A7TR Q VDD VNW VPW VSS CK D SE SI SN
mX_g8_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net123 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 nmrs nmse net123 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t6 nmrs SE net150 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net150 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI57_MXNOE nm cn nmrs VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNOE nm c XI7_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 XI7_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t13 m nm NSN VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI81_MXNOE s c m VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN11 s cn net141 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN12 NSN ns net141 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t14 NSN SN VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g8_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t7 net83 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP10 nmrs SE net83 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP9 net113 nmse nmrs VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 VDD SI net113 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI57_MXPOEN nm c nmrs VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPOEN nm cn XI7_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA1 XI7_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP11 VDD nm m VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI81_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP12 VDD SN m VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP13 VDD SN s VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP14 net107 c s VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP15 net107 ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFSQ_X4_A7TR Q VDD VNW VPW VSS CK D SE SI SN
mX_g8_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net123 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 nmrs nmse net123 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t6 nmrs SE net150 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net150 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI57_MXNOE nm cn nmrs VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNOE nm c XI7_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 XI7_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t13 m nm NSN VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI81_MXNOE s c m VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN11 s cn net141 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN12 NSN ns net141 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t14 NSN SN VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g8_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t7 net83 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP10 nmrs SE net83 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP9 net113 nmse nmrs VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 VDD SI net113 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI57_MXPOEN nm c nmrs VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPOEN nm cn XI7_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA1 XI7_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP11 VDD nm m VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI81_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP12 VDD SN m VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP13 VDD SN s VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP14 net107 c s VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP15 net107 ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFSRHQ_X1_A7TR Q VDD VNW VPW VSS CK D RN SE SI SN
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN11 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g13_MXNA1 wlnmin D VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI82_MXNOE nmsi nmse wlnmin VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNOE nmsi SE XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 XI1_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI80_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nmset SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN13 net142 SN VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN12 net166 cn net142 VPW N18_DNW L=1.8e-07 W=6.8e-07
MX_t25 m nmsi net166 VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI12_MXNOE m c XI12_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI12_MXNA1 XI12_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t10 nm m net170 VPW N18_DNW L=1.8e-07 W=6.5e-07
MXN14 net170 RN VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
MX_t6 nm nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI81_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=5.5e-07
MXN16 ns cn net162 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN17 net162 RN net159 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN18 VSS s net159 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN15 ns nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP11 net111 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP12 net111 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
mX_g13_MXPA1 wlnmin D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI82_MXPOEN nmsi SE wlnmin VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPOEN nmsi nmse XI1_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 XI1_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI80_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nmset SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t12 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP14 m nmsi net131 VNW P18_DNW L=1.8e-07 W=6.3e-07
MX_t28 net131 c VDD VNW P18_DNW L=1.8e-07 W=6.3e-07
mXI12_MXPOEN m cn XI12_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI12_MXPA1 XI12_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t11 nm m VDD VNW P18_DNW L=1.8e-07 W=8.3e-07
MXP15 net117 nmset VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP16 nm RN net117 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI81_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=8.3e-07
MXP21 ns nmset net93 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP17 net93 RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP20 ns c net105 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP19 net105 nmset net101 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP18 VDD s net101 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT SDFFSRHQ_X2_A7TR Q VDD VNW VPW VSS CK D RN SE SI SN
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN11 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g13_MXNA1 wlnmin D VSS VPW N18_DNW L=1.8e-07 W=5.2e-07
mXI82_MXNOE nmsi nmse wlnmin VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNOE nmsi SE XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 XI1_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI80_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nmset SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN13 net142 SN VSS VPW N18_DNW L=1.8e-07 W=9.2e-07
MXN12 net166 cn net142 VPW N18_DNW L=1.8e-07 W=9.2e-07
MX_t25 m nmsi net166 VPW N18_DNW L=1.8e-07 W=9.2e-07
mXI12_MXNOE m c XI12_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI12_MXNA1 XI12_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t10 nm m net170 VPW N18_DNW L=1.8e-07 W=8.9e-07
MXN14 net170 RN VSS VPW N18_DNW L=1.8e-07 W=8.9e-07
MX_t6 nm nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI81_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=7e-07
MXN16 ns cn net162 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN17 net162 RN net159 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN18 VSS s net159 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN15 ns nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP11 net111 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP12 net111 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mX_g13_MXPA1 wlnmin D VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI82_MXPOEN nmsi SE wlnmin VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPOEN nmsi nmse XI1_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 XI1_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI80_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nmset SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t12 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP14 m nmsi net131 VNW P18_DNW L=1.8e-07 W=8.8e-07
MX_t28 net131 c VDD VNW P18_DNW L=1.8e-07 W=8.8e-07
mXI12_MXPOEN m cn XI12_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI12_MXPA1 XI12_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t11 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP15 net117 nmset VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP16 nm RN net117 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI81_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=9.8e-07
MXP21 ns nmset net93 VNW P18_DNW L=1.8e-07 W=4.3e-07
MXP17 net93 RN VDD VNW P18_DNW L=1.8e-07 W=4.3e-07
MXP20 ns c net105 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP19 net105 nmset net101 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP18 VDD s net101 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFSRHQ_X4_A7TR Q VDD VNW VPW VSS CK D RN SE SI SN
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=5.5e-07
MXN11 cn CK VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mX_g13_MXNA1 wlnmin D VSS VPW N18_DNW L=1.8e-07 W=9e-07
mXI82_MXNOE nmsi nmse wlnmin VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI1_MXNOE nmsi SE XI1_n1 VPW N18_DNW L=1.8e-07 W=4.6e-07
mXI1_MXNA1 XI1_n1 SI VSS VPW N18_DNW L=1.8e-07 W=4.6e-07
mXI80_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nmset SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN13_2 net142__2 SN VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN12_2 net166__2 cn net142__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t25_2 m nmsi net166__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t25 m nmsi net166 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN12 net166 cn net142 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN13 net142 SN VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
mXI12_MXNOE m c XI12_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI12_MXNA1 XI12_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN14_2 net170__2 RN VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
MX_t10_2 nm m net170__2 VPW N18_DNW L=1.8e-07 W=7.5e-07
MX_t10 nm m net170 VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN14 net170 RN VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
MX_t6 nm nmset VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mXI81_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN16 ns cn net162 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN17 net162 RN net159 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN18 VSS s net159 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN15 ns nmset VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=5.5e-07
MXP11 net111 CK VDD VNW P18_DNW L=1.8e-07 W=1.24e-06
MXP12 net111 c cn VNW P18_DNW L=1.8e-07 W=1.24e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=9.5e-07
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=9.5e-07
mX_g13_MXPA1 wlnmin D VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI82_MXPOEN nmsi SE wlnmin VNW P18_DNW L=1.8e-07 W=6.9e-07
mXI1_MXPOEN nmsi nmse XI1_p1 VNW P18_DNW L=1.8e-07 W=6.9e-07
mXI1_MXPA1 XI1_p1 SI VDD VNW P18_DNW L=1.8e-07 W=6.9e-07
mXI80_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nmset SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t12 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t28_2 net131__2 c VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP14_2 m nmsi net131__2 VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP14 m nmsi net131 VNW P18_DNW L=1.8e-07 W=4.9e-07
MX_t28 net131 c VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
mXI12_MXPA1 XI12_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI12_MXPOEN m cn XI12_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t11 nm m VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MX_t11_2 nm m VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP15 net117 nmset VDD VNW P18_DNW L=1.8e-07 W=5.3e-07
MXP16 nm RN net117 VNW P18_DNW L=1.8e-07 W=5.3e-07
mXI81_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=4.1e-07
mXI81_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.2e-06
MXP17 net93 RN VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
MXP21 ns nmset net93 VNW P18_DNW L=1.8e-07 W=8.5e-07
MXP20 ns c net105 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP19 net105 nmset net101 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP18 VDD s net101 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFSRHQ_X8_A7TR Q VDD VNW VPW VSS CK D RN SE SI SN
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=5.5e-07
MXN11 cn CK VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mX_g13_MXNA1 wlnmin D VSS VPW N18_DNW L=1.8e-07 W=9e-07
mXI82_MXNOE nmsi nmse wlnmin VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI1_MXNOE nmsi SE XI1_n1 VPW N18_DNW L=1.8e-07 W=4.6e-07
mXI1_MXNA1 XI1_n1 SI VSS VPW N18_DNW L=1.8e-07 W=4.6e-07
mXI80_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nmset SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN13_2 net142__2 SN VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN12_2 net166__2 cn net142__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t25_2 m nmsi net166__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t25 m nmsi net166 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN12 net166 cn net142 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN13 net142 SN VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
mXI12_MXNOE m c XI12_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI12_MXNA1 XI12_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN14_2 net170__2 RN VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
MX_t10_2 nm m net170__2 VPW N18_DNW L=1.8e-07 W=7.5e-07
MX_t10 nm m net170 VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN14 net170 RN VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
MX_t6 nm nmset VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mXI81_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN16 ns cn net162 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN17 net162 RN net159 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN18 VSS s net159 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN15 ns nmset VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_3 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_4 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=5.5e-07
MXP11 net111 CK VDD VNW P18_DNW L=1.8e-07 W=1.24e-06
MXP12 net111 c cn VNW P18_DNW L=1.8e-07 W=1.24e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=9.5e-07
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=9.5e-07
mX_g13_MXPA1 wlnmin D VDD VNW P18_DNW L=1.8e-07 W=1.29e-06
mXI82_MXPOEN nmsi SE wlnmin VNW P18_DNW L=1.8e-07 W=6.9e-07
mXI1_MXPOEN nmsi nmse XI1_p1 VNW P18_DNW L=1.8e-07 W=6.9e-07
mXI1_MXPA1 XI1_p1 SI VDD VNW P18_DNW L=1.8e-07 W=6.9e-07
mXI80_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nmset SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t12 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t28_2 net131__2 c VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP14_2 m nmsi net131__2 VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP14 m nmsi net131 VNW P18_DNW L=1.8e-07 W=4.9e-07
MX_t28 net131 c VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
mXI12_MXPA1 XI12_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI12_MXPOEN m cn XI12_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t11 nm m VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MX_t11_2 nm m VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP15 net117 nmset VDD VNW P18_DNW L=1.8e-07 W=5.3e-07
MXP16 nm RN net117 VNW P18_DNW L=1.8e-07 W=5.3e-07
mXI81_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=4.1e-07
mXI81_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.2e-06
MXP17 net93 RN VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
MXP21 ns nmset net93 VNW P18_DNW L=1.8e-07 W=8.7e-07
MXP20 ns c net105 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP19 net105 nmset net101 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP18 VDD s net101 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_3 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_4 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFSR_X1_A7TR Q QN VDD VNW VPW VSS CK D RN SE SI SN
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNA1 XI3_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNOE nmrs nmse XI3_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNOE nmrs SE XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI69_MXNOE nm cn nmrs VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI8_MXNOE nm c XI8_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI8_MXNA1 XI8_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t13 m nm NSN VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI71_MXNOE s c m VPW N18_DNW L=1.8e-07 W=2.9e-07
MX_t20 s cn net75 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 NSN ns net75 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 s NRN NSN VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t15 NSN NRN m VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t14 NSN SN VSS VPW N18_DNW L=1.8e-07 W=6e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 NRN RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI3_MXPA1 XI3_p1 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI3_MXPOEN nmrs SE XI3_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPOEN nmrs nmse XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 XI0_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI69_MXPOEN nm c nmrs VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI8_MXPOEN nm cn XI8_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI8_MXPA1 XI8_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t11 m nm brn VNW P18_DNW L=1.8e-07 W=6.7e-07
mXI71_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=4.4e-07
MXP6 s c net105 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 brn ns net105 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t12 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t16 s SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MX_t10 brn NRN VDD VNW P18_DNW L=1.8e-07 W=9e-07
mX_g5_MXPA1 NRN RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT SDFFSR_X2_A7TR Q QN VDD VNW VPW VSS CK D RN SE SI SN
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNA1 XI3_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNOE nmrs nmse XI3_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNOE nmrs SE XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI69_MXNOE nm cn nmrs VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI8_MXNOE nm c XI8_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI8_MXNA1 XI8_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t13 m nm NSN VPW N18_DNW L=1.8e-07 W=2.2e-07
MX_t13_2 m nm NSN VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI71_MXNOE s c m VPW N18_DNW L=1.8e-07 W=4.2e-07
MX_t20 s cn net75 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 NSN ns net75 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 s NRN NSN VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t15 NSN NRN m VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t14 NSN SN VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 NRN RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI3_MXPA1 XI3_p1 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI3_MXPOEN nmrs SE XI3_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPOEN nmrs nmse XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 XI0_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.09e-06
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI69_MXPOEN nm c nmrs VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI8_MXPOEN nm cn XI8_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI8_MXPA1 XI8_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t11 m nm brn VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI71_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=6.1e-07
MXP6 s c net105 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 brn ns net105 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t12 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t16 s SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t10 brn NRN VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g5_MXPA1 NRN RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFSR_X4_A7TR Q QN VDD VNW VPW VSS CK D RN SE SI SN
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNA1 XI3_n1 D VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
mXI3_MXNOE nmrs nmse XI3_n1 VPW N18_DNW L=1.8e-07 W=3.9e-07
mXI0_MXNOE nmrs SE XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI69_MXNOE nm cn nmrs VPW N18_DNW L=1.8e-07 W=3.9e-07
mXI8_MXNOE nm c XI8_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI8_MXNA1 XI8_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t13 m nm NSN VPW N18_DNW L=1.8e-07 W=4.4e-07
MX_t13_2 m nm NSN VPW N18_DNW L=1.8e-07 W=4.6e-07
mXI71_MXNOE s c m VPW N18_DNW L=1.8e-07 W=7.3e-07
MX_t20 s cn net75 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 NSN ns net75 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 s NRN NSN VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t15 NSN NRN m VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t14 NSN SN VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXNA1 NRN RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g3_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI3_MXPA1 XI3_p1 D VDD VNW P18_DNW L=1.8e-07 W=5.9e-07
mXI3_MXPOEN nmrs SE XI3_p1 VNW P18_DNW L=1.8e-07 W=5.9e-07
mXI0_MXPOEN nmrs nmse XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 XI0_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.34e-06
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI69_MXPOEN nm c nmrs VNW P18_DNW L=1.8e-07 W=5.9e-07
mXI8_MXPOEN nm cn XI8_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI8_MXPA1 XI8_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t11 m nm brn VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI71_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=8.4e-07
MXP6 s c net105 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 brn ns net105 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t12 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t16 s SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t10 brn NRN VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t10_2 brn NRN VDD VNW P18_DNW L=1.8e-07 W=5.8e-07
mX_g5_MXPA1 NRN RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFS_X1_A7TR Q QN VDD VNW VPW VSS CK D SE SI SN
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNA1 XI3_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNOE nmrs nmse XI3_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNOE nmrs SE XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI71_MXNOE nm cn nmrs VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI2_MXNOE nm c XI2_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI2_MXNA1 XI2_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t11 m nm BSN VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI34_MXNOE s c m VPW N18_DNW L=1.8e-07 W=2.9e-07
MX_t19 s cn net138 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 BSN ns net138 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t33 BSN SN VSS VPW N18_DNW L=1.8e-07 W=6e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI33_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI3_MXPA1 XI3_p1 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI3_MXPOEN nmrs SE XI3_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPOEN nmrs nmse XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 XI0_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI71_MXPOEN nm c nmrs VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI2_MXPOEN nm cn XI2_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI2_MXPA1 XI2_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 m nm VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI34_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=4.4e-07
MX_t24 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP3 s SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 s c net104 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 VDD ns net104 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI33_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=8.9e-07
.ends


.SUBCKT SDFFS_X2_A7TR Q QN VDD VNW VPW VSS CK D SE SI SN
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNA1 XI3_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNOE nmrs nmse XI3_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNOE nmrs SE XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI71_MXNOE nm cn nmrs VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI2_MXNOE nm c XI2_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI2_MXNA1 XI2_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t11 m nm BSN VPW N18_DNW L=1.8e-07 W=4.2e-07
MX_t11_2 m nm BSN VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI34_MXNOE s c m VPW N18_DNW L=1.8e-07 W=4.2e-07
MX_t19 s cn net138 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 BSN ns net138 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t33 BSN SN VSS VPW N18_DNW L=1.8e-07 W=7.2e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI33_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI3_MXPA1 XI3_p1 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI3_MXPOEN nmrs SE XI3_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPOEN nmrs nmse XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 XI0_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.09e-06
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI71_MXPOEN nm c nmrs VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI2_MXPOEN nm cn XI2_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI2_MXPA1 XI2_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 m nm VDD VNW P18_DNW L=1.8e-07 W=6.1e-07
mXI34_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=6.1e-07
MX_t24 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP3 s SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 s c net104 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 VDD ns net104 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI33_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFS_X4_A7TR Q QN VDD VNW VPW VSS CK D SE SI SN
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNA1 XI3_n1 D VSS VPW N18_DNW L=1.8e-07 W=3.1e-07
mXI3_MXNOE nmrs nmse XI3_n1 VPW N18_DNW L=1.8e-07 W=3.1e-07
mXI0_MXNOE nmrs SE XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=4.7e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI71_MXNOE nm cn nmrs VPW N18_DNW L=1.8e-07 W=3.1e-07
mXI2_MXNOE nm c XI2_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI2_MXNA1 XI2_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t11 m nm BSN VPW N18_DNW L=1.8e-07 W=4.2e-07
MX_t11_2 m nm BSN VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI34_MXNOE s c m VPW N18_DNW L=1.8e-07 W=7.3e-07
MX_t19 s cn net138 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 BSN ns net138 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t33 BSN SN VSS VPW N18_DNW L=1.8e-07 W=1.15e-06
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI33_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI33_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI3_MXPA1 XI3_p1 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI3_MXPOEN nmrs SE XI3_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPOEN nmrs nmse XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 XI0_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.2e-06
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI71_MXPOEN nm c nmrs VNW P18_DNW L=1.8e-07 W=4.7e-07
mXI2_MXPOEN nm cn XI2_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI2_MXPA1 XI2_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 m nm VDD VNW P18_DNW L=1.8e-07 W=8e-07
mXI34_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=1.1e-06
MX_t24 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP3 s SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 s c net104 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 VDD ns net104 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI33_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI33_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFTR_X1_A7TR Q QN VDD VNW VPW VSS CK D RN SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net181 D net074 VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t7 nmrs nmse net181 VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t3 nmrs SE net193 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net193 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 net074 RN VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI43_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI69_MXNOE nm cn nmrs VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNOE nm c XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNA1 XI7_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI47_MXNOE s c m VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI8_MXNOE s cn XI8_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI8_MXNA1 XI8_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI46_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t5 net96 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP7 nmrs SE net96 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP6 nmrs nmse net114 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t1 net114 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 net105 SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9 nmrs RN net105 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI43_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI69_MXPOEN nm c nmrs VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPOEN nm cn XI7_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXPA1 XI7_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=8.3e-07
mXI47_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=8.3e-07
mXI8_MXPOEN s c XI8_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI8_MXPA1 XI8_p1 ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI46_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT SDFFTR_X2_A7TR Q QN VDD VNW VPW VSS CK D RN SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net181 D net074 VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t7 nmrs nmse net181 VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t3 nmrs SE net193 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net193 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 net074 RN VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mXI43_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI69_MXNOE nm cn nmrs VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNOE nm c XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNA1 XI7_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI47_MXNOE s c m VPW N18_DNW L=1.8e-07 W=5.5e-07
mXI8_MXNOE s cn XI8_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI8_MXNA1 XI8_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI46_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t5 net96 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP7 nmrs SE net96 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP6 nmrs nmse net114 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t1 net114 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 net105 SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9 nmrs RN net105 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
mXI43_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI69_MXPOEN nm c nmrs VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPOEN nm cn XI7_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXPA1 XI7_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=1.13e-06
mXI47_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=1.13e-06
mXI8_MXPOEN s c XI8_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI8_MXPA1 XI8_p1 ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI46_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFFTR_X4_A7TR Q QN VDD VNW VPW VSS CK D RN SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net181 D net074 VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t7 nmrs nmse net181 VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t3 nmrs SE net193 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net193 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 net074 RN VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mXI43_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI69_MXNOE nm cn nmrs VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNOE nm c XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNA1 XI7_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI47_MXNOE s c m VPW N18_DNW L=1.8e-07 W=5.5e-07
mXI8_MXNOE s cn XI8_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI8_MXNA1 XI8_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI46_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI46_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t5 net96 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP7 nmrs SE net96 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP6 nmrs nmse net114 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t1 net114 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 net105 SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9 nmrs RN net105 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
mXI43_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI69_MXPOEN nm c nmrs VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPOEN nm cn XI7_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXPA1 XI7_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=1.13e-06
mXI47_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=1.13e-06
mXI8_MXPOEN s c XI8_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI8_MXPA1 XI8_p1 ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI46_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI46_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFF_X1_A7TR Q QN VDD VNW VPW VSS CK D SE SI
mX_g8_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net137 SE net116 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 net116 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net119 nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 net137 D net119 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 nm cn net137 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI17_MXNOE nm c XI17_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI17_MXNA1 XI17_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI57_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI15_MXNA1 XI15_n1 m VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI15_MXNOE ns c XI15_n1 VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXNOE ns cn XI16_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI16_MXNA1 XI16_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI58_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g8_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 net77 nmse net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t8 net73 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 net76 SE VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP3 net77 D net76 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP4 nm c net77 VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI17_MXPOEN nm cn XI17_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI17_MXPA1 XI17_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI57_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI15_MXPA1 XI15_p1 m VDD VNW P18_DNW L=1.8e-07 W=6.2e-07
mXI15_MXPOEN ns cn XI15_p1 VNW P18_DNW L=1.8e-07 W=6.2e-07
mXI16_MXPOEN ns c XI16_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI16_MXPA1 XI16_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI58_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT SDFF_X2_A7TR Q QN VDD VNW VPW VSS CK D SE SI
mX_g8_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net137 SE net116 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 net116 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net119 nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 net137 D net119 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 nm cn net137 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI17_MXNOE nm c XI17_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI17_MXNA1 XI17_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mXI57_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI15_MXNA1 XI15_n1 m VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI15_MXNOE ns c XI15_n1 VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI16_MXNOE ns cn XI16_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI16_MXNA1 XI16_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI58_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g8_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 net77 nmse net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t8 net73 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 net76 SE VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP3 net77 D net76 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP4 nm c net77 VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI17_MXPOEN nm cn XI17_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI17_MXPA1 XI17_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
mXI57_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI15_MXPA1 XI15_p1 m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI15_MXPOEN ns cn XI15_p1 VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI16_MXPOEN ns c XI16_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI16_MXPA1 XI16_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI58_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SDFF_X4_A7TR Q QN VDD VNW VPW VSS CK D SE SI
mX_g8_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net137 SE net116 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 net116 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net119 nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 net137 D net119 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 nm cn net137 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI17_MXNOE nm c XI17_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI17_MXNA1 XI17_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI57_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI15_MXNA1 XI15_n1 m VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI15_MXNA1_2 XI15_n1 m VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI15_MXNOE ns c XI15_n1 VPW N18_DNW L=1.8e-07 W=5.6e-07
mXI15_MXNOE_2 ns c XI15_n1 VPW N18_DNW L=1.8e-07 W=5.6e-07
mXI16_MXNOE ns cn XI16_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI16_MXNA1 XI16_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
mXI58_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI58_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g8_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 net77 nmse net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t8 net73 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 net76 SE VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP3 net77 D net76 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP4 nm c net77 VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI17_MXPOEN nm cn XI17_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI17_MXPA1 XI17_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=5.3e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mXI57_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI15_MXPA1 XI15_p1 m VDD VNW P18_DNW L=1.8e-07 W=8.4e-07
mXI15_MXPA1_2 XI15_p1 m VDD VNW P18_DNW L=1.8e-07 W=8.4e-07
mXI15_MXPOEN ns cn XI15_p1 VNW P18_DNW L=1.8e-07 W=8.4e-07
mXI15_MXPOEN_2 ns cn XI15_p1 VNW P18_DNW L=1.8e-07 W=8.4e-07
mXI16_MXPOEN ns c XI16_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI16_MXPA1 XI16_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g9_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
mXI58_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI58_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SEDFFHQ_X1_A7TR Q VDD VNW VPW VSS CK D E SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNA1 XI16_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNOE nmsi SE XI16_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI65_MXNOE nmsi nmse2 nmin VPW N18_DNW L=1.8e-07 W=3.8e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=3.8e-07
mX_g8_MXNA1 nmse2 se2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 se2 E XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 XI0_n1 nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA2 nmen2 SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 nmen2 E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 en2 nmen2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI8_MXNOE nmsi nmen2 XI8_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI8_MXNA1 XI8_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
MXN2 net0121 cn VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
MXN0 m nmsi net0121 VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI15_MXNOE m c XI15_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI15_MXNA1 XI15_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI93_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI13_MXNOE ns cn XI13_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI13_MXNA1 XI13_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPA1 XI16_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPOEN nmsi nmse XI16_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1e-06
mXI65_MXPOEN nmsi se2 nmin VNW P18_DNW L=1.8e-07 W=5.8e-07
mX_g8_MXPA1 nmse2 se2 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 se2 E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA2 se2 nmse VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA2 XI7_p1 SE VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI7_MXPA1 nmen2 E XI7_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g6_MXPA1 en2 nmen2 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI8_MXPOEN nmsi en2 XI8_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI8_MXPA1 XI8_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 net079 CK VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
MXP4 net079 c cn VNW P18_DNW L=1.8e-07 W=6.8e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.08e-06
MXP0 net78 c VDD VNW P18_DNW L=1.8e-07 W=8.1e-07
MXP5 m nmsi net78 VNW P18_DNW L=1.8e-07 W=8.1e-07
mXI15_MXPOEN m cn XI15_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI15_MXPA1 XI15_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI93_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.07e-06
mXI13_MXPOEN ns c XI13_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI13_MXPA1 XI13_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT SEDFFHQ_X2_A7TR Q VDD VNW VPW VSS CK D E SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNA1 XI16_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNOE nmsi SE XI16_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI65_MXNOE nmsi nmse2 nmin VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g8_MXNA1 nmse2 se2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 se2 E XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 XI0_n1 nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA2 nmen2 SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 nmen2 E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 en2 nmen2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI8_MXNOE nmsi nmen2 XI8_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI8_MXNA1 XI8_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=3e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=4.7e-07
MXN2 net0121 cn VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
MXN0 m nmsi net0121 VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI15_MXNOE m c XI15_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI15_MXNA1 XI15_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI93_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8.3e-07
mXI13_MXNOE ns cn XI13_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI13_MXNA1 XI13_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPA1 XI16_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPOEN nmsi nmse XI16_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI65_MXPOEN nmsi se2 nmin VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g8_MXPA1 nmse2 se2 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 se2 E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA2 se2 nmse VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA2 XI7_p1 SE VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI7_MXPA1 nmen2 E XI7_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g6_MXPA1 en2 nmen2 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI8_MXPOEN nmsi en2 XI8_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI8_MXPA1 XI8_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 net079 CK VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
MXP4 net079 c cn VNW P18_DNW L=1.8e-07 W=6.8e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP0 net78 c VDD VNW P18_DNW L=1.8e-07 W=8.2e-07
MXP5 m nmsi net78 VNW P18_DNW L=1.8e-07 W=8.2e-07
mXI15_MXPOEN m cn XI15_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI15_MXPA1 XI15_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI93_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI13_MXPOEN ns c XI13_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI13_MXPA1 XI13_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SEDFFHQ_X4_A7TR Q VDD VNW VPW VSS CK D E SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNA1 XI16_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNOE nmsi SE XI16_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI65_MXNOE nmsi nmse2 nmin VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mX_g8_MXNA1 nmse2 se2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 se2 E XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 XI0_n1 nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA2 nmen2 SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 nmen2 E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 en2 nmen2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI8_MXNOE nmsi nmen2 XI8_n1 VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI8_MXNA1 XI8_n1 s VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN2_2 net0121__2 cn VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN0_2 m nmsi net0121__2 VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN0 m nmsi net0121 VPW N18_DNW L=1.8e-07 W=5.3e-07
MXN2 net0121 cn VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI15_MXNOE m c XI15_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI15_MXNA1 XI15_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=7.8e-07
mX_g7_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI93_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=1.26e-06
mXI13_MXNOE ns cn XI13_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI13_MXNA1 XI13_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPA1 XI16_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPOEN nmsi nmse XI16_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.13e-06
mX_g13_MXPA1_2 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.13e-06
mXI65_MXPOEN nmsi se2 nmin VNW P18_DNW L=1.8e-07 W=1.37e-06
mX_g8_MXPA1 nmse2 se2 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 se2 E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA2 se2 nmse VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA2 XI7_p1 SE VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI7_MXPA1 nmen2 E XI7_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g6_MXPA1 en2 nmen2 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI8_MXPOEN nmsi en2 XI8_p1 VNW P18_DNW L=1.8e-07 W=5.5e-07
mXI8_MXPA1 XI8_p1 s VDD VNW P18_DNW L=1.8e-07 W=5.5e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=6.1e-07
MX_t10 net079 CK VDD VNW P18_DNW L=1.8e-07 W=1.36e-06
MXP4 net079 c cn VNW P18_DNW L=1.8e-07 W=1.36e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.05e-06
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=1.04e-06
MXP0_2 net78__2 c VDD VNW P18_DNW L=1.8e-07 W=8.2e-07
MXP5_2 m nmsi net78__2 VNW P18_DNW L=1.8e-07 W=8.2e-07
MXP5 m nmsi net78 VNW P18_DNW L=1.8e-07 W=1.1e-06
MXP0 net78 c VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI15_MXPOEN m cn XI15_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI15_MXPA1 XI15_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mX_g7_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI13_MXPOEN ns c XI13_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPA1 XI13_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI93_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=8.6e-07
mXI93_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.4e-06
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SEDFFHQ_X8_A7TR Q VDD VNW VPW VSS CK D E SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI16_MXNA1 XI16_n1 SI VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXNOE nmsi SE XI16_n1 VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI65_MXNOE nmsi nmse2 nmin VPW N18_DNW L=1.8e-07 W=1.29e-06
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mX_g13_MXNA1_2 nmin D VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mX_g8_MXNA1 nmse2 se2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 se2 E XI0_n1 VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI0_MXNA2 XI0_n1 nmse VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI7_MXNA2 nmen2 SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 nmen2 E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 en2 nmen2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI8_MXNOE nmsi nmen2 XI8_n1 VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI8_MXNA1 XI8_n1 s VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MX_t6 cn CK VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g14_MXNA1_2 nck CK VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mX_g10_MXNA1_2 c nck VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
MXN2_2 net0121__2 cn VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
MXN0_2 m nmsi net0121__2 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN0_3 m nmsi net0121__3 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN2_3 net0121__3 cn VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
MXN2_4 net0121__4 cn VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
MXN0_4 m nmsi net0121__4 VPW N18_DNW L=1.8e-07 W=3.6e-07
MXN0 m nmsi net0121 VPW N18_DNW L=1.8e-07 W=4.8e-07
MXN2 net0121 cn VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
mXI15_MXNOE m c XI15_n1 VPW N18_DNW L=1.8e-07 W=3e-07
mXI15_MXNA1 XI15_n1 nm VSS VPW N18_DNW L=1.8e-07 W=3e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=8e-07
mX_g7_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=8e-07
mX_g7_MXNA1_3 nm m VSS VPW N18_DNW L=1.8e-07 W=8e-07
mXI93_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=1.28e-06
mXI93_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=1.28e-06
mXI13_MXNOE ns cn XI13_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI13_MXNA1 XI13_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=3e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_3 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_4 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI16_MXPA1 XI16_p1 SI VDD VNW P18_DNW L=1.8e-07 W=6.4e-07
mXI16_MXPOEN nmsi nmse XI16_p1 VNW P18_DNW L=1.8e-07 W=6.4e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
mX_g13_MXPA1_2 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g13_MXPA1_3 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.37e-06
mXI65_MXPOEN nmsi se2 nmin VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI65_MXPOEN_2 nmsi se2 nmin VNW P18_DNW L=1.8e-07 W=1.27e-06
mX_g8_MXPA1 nmse2 se2 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 se2 E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA2 se2 nmse VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA2 XI7_p1 SE VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI7_MXPA1 nmen2 E XI7_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g6_MXPA1 en2 nmen2 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI8_MXPOEN nmsi en2 XI8_p1 VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI8_MXPA1 XI8_p1 s VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=1.07e-06
MX_t10_2 net079__2 CK VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
MXP4_2 net079__2 c cn VNW P18_DNW L=1.8e-07 W=1.12e-06
MXP4 net079 c cn VNW P18_DNW L=1.8e-07 W=1.12e-06
MX_t10 net079 CK VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.37e-06
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=1.37e-06
MXP0_2 net78__2 c VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP5_2 m nmsi net78__2 VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP5_3 m nmsi net78__3 VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP0_3 net78__3 c VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP0_4 net78__4 c VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP5_4 m nmsi net78__4 VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP5 m nmsi net78 VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP0 net78 c VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
mXI15_MXPOEN m cn XI15_p1 VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI15_MXPA1 XI15_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.37e-06
mX_g7_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=1.37e-06
mX_g7_MXPA1_3 nm m VDD VNW P18_DNW L=1.8e-07 W=1.37e-06
mXI13_MXPOEN ns c XI13_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPA1 XI13_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI93_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=8.6e-07
mXI93_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI93_MXPOEN_3 ns cn nm VNW P18_DNW L=1.8e-07 W=1.64e-06
mXI93_MXPOEN_4 ns cn nm VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.6e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_3 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_4 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SEDFFTR_X1_A7TR Q QN VDD VNW VPW VSS CK D E RN SE SI
mX_g12_MXNA1 nmen E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI43_MXNA1 be nmen VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g9_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=3.1e-07
mXI41_MXNOE nmin_pass1 be nmin VPW N18_DNW L=1.8e-07 W=3.1e-07
mXI40_MXNOE nmin_pass1 nmen ns VPW N18_DNW L=1.8e-07 W=3.1e-07
mX_g13_MXNA1 nmsi SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI47_MXNOE nmin_pass2 bse nmsi VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI39_MXNOE nmin_pass2 nmse nmin_pass1 VPW N18_DNW L=1.8e-07 W=3.1e-07
mXI45_MXNA1 bse nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI44_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 nmrs SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t9 nmrs RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net169 nmrs VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t5 net169 nmin_pass2 VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t4 m cn net169 VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI0_MXNOE m c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI42_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mX_g18_MXNA1 bm nm VSS VPW N18_DNW L=1.8e-07 W=5.2e-07
mXI48_MXNOE s c bm VPW N18_DNW L=1.8e-07 W=5.2e-07
mXI1_MXNOE s cn XI1_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA1 XI1_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI46_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g12_MXPA1 nmen E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI43_MXPA1 be nmen VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g9_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=4.6e-07
mXI41_MXPOEN nmin_pass1 nmen nmin VNW P18_DNW L=1.8e-07 W=4.6e-07
mXI40_MXPOEN nmin_pass1 be ns VNW P18_DNW L=1.8e-07 W=4.6e-07
mX_g13_MXPA1 nmsi SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI47_MXPOEN nmin_pass2 nmse nmsi VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI39_MXPOEN nmin_pass2 bse nmin_pass1 VNW P18_DNW L=1.8e-07 W=4.6e-07
mXI45_MXPA1 bse nmse VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI44_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t7 net108 SE VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP4 nmrs RN net108 VNW P18_DNW L=1.8e-07 W=5.6e-07
MX_t1 net102 nmrs VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP5 net111 nmin_pass2 net102 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP6 m c net111 VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI0_MXPOEN m cn XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 XI0_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI42_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
mX_g18_MXPA1 bm nm VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI48_MXPOEN s cn bm VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI1_MXPOEN s c XI1_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 XI1_p1 ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
mXI46_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT SEDFFTR_X2_A7TR Q QN VDD VNW VPW VSS CK D E RN SE SI
mX_g12_MXNA1 nmen E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI43_MXNA1 be nmen VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g9_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=3.1e-07
mXI41_MXNOE nmin_pass1 be nmin VPW N18_DNW L=1.8e-07 W=3.1e-07
mXI40_MXNOE nmin_pass1 nmen ns VPW N18_DNW L=1.8e-07 W=3.1e-07
mX_g13_MXNA1 nmsi SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI47_MXNOE nmin_pass2 bse nmsi VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI39_MXNOE nmin_pass2 nmse nmin_pass1 VPW N18_DNW L=1.8e-07 W=3.1e-07
mXI45_MXNA1 bse nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI44_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 nmrs SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t9 nmrs RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net169 nmrs VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t5 net169 nmin_pass2 VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t4 m cn net169 VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI0_MXNOE m c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI42_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.2e-07
mX_g18_MXNA1 bm nm VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI48_MXNOE s c bm VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI1_MXNOE s cn XI1_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA1 XI1_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
mXI46_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g12_MXPA1 nmen E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI43_MXPA1 be nmen VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g9_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=4.6e-07
mXI41_MXPOEN nmin_pass1 nmen nmin VNW P18_DNW L=1.8e-07 W=4.6e-07
mXI40_MXPOEN nmin_pass1 be ns VNW P18_DNW L=1.8e-07 W=4.6e-07
mX_g13_MXPA1 nmsi SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI47_MXPOEN nmin_pass2 nmse nmsi VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI39_MXPOEN nmin_pass2 bse nmin_pass1 VNW P18_DNW L=1.8e-07 W=4.6e-07
mXI45_MXPA1 bse nmse VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI44_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t7 net108 SE VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP4 nmrs RN net108 VNW P18_DNW L=1.8e-07 W=5.6e-07
MX_t1 net102 nmrs VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP5 net111 nmin_pass2 net102 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP6 m c net111 VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI0_MXPOEN m cn XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 XI0_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI42_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=8.9e-07
mX_g18_MXPA1 bm nm VDD VNW P18_DNW L=1.8e-07 W=9.5e-07
mXI48_MXPOEN s cn bm VNW P18_DNW L=1.8e-07 W=9.5e-07
mXI1_MXPOEN s c XI1_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 XI1_p1 ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
mXI46_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SEDFFTR_X4_A7TR Q QN VDD VNW VPW VSS CK D E RN SE SI
mX_g12_MXNA1 nmen E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI43_MXNA1 be nmen VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g9_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=3.1e-07
mXI41_MXNOE nmin_pass1 be nmin VPW N18_DNW L=1.8e-07 W=3.1e-07
mXI40_MXNOE nmin_pass1 nmen ns VPW N18_DNW L=1.8e-07 W=3.1e-07
mX_g13_MXNA1 nmsi SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI47_MXNOE nmin_pass2 bse nmsi VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI39_MXNOE nmin_pass2 nmse nmin_pass1 VPW N18_DNW L=1.8e-07 W=3.1e-07
mXI45_MXNA1 bse nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI44_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 nmrs SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t9 nmrs RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net169 nmrs VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t5 net169 nmin_pass2 VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
MX_t4 m cn net169 VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI0_MXNOE m c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
mXI42_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=4e-07
mX_g18_MXNA1 bm nm VSS VPW N18_DNW L=1.8e-07 W=1.03e-06
mXI48_MXNOE s c bm VPW N18_DNW L=1.8e-07 W=1.07e-06
mXI1_MXNOE s cn XI1_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA1 XI1_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI46_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI46_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g12_MXPA1 nmen E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI43_MXPA1 be nmen VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g9_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=4.6e-07
mXI41_MXPOEN nmin_pass1 nmen nmin VNW P18_DNW L=1.8e-07 W=4.6e-07
mXI40_MXPOEN nmin_pass1 be ns VNW P18_DNW L=1.8e-07 W=4.6e-07
mX_g13_MXPA1 nmsi SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI47_MXPOEN nmin_pass2 nmse nmsi VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI39_MXPOEN nmin_pass2 bse nmin_pass1 VNW P18_DNW L=1.8e-07 W=4.6e-07
mXI45_MXPA1 bse nmse VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI44_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t7 net108 SE VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP4 nmrs RN net108 VNW P18_DNW L=1.8e-07 W=5.6e-07
MX_t1 net102 nmrs VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP5 net111 nmin_pass2 net102 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP6 m c net111 VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI0_MXPOEN m cn XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 XI0_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=5.8e-07
mXI42_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
mX_g18_MXPA1 bm nm VDD VNW P18_DNW L=1.8e-07 W=9.5e-07
mXI48_MXPOEN s cn bm VNW P18_DNW L=1.8e-07 W=9.5e-07
mXI1_MXPOEN s c XI1_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 XI1_p1 ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
mXI46_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI46_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SEDFF_X1_A7TR Q QN VDD VNW VPW VSS CK D E SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net100 nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN11 net92 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN12 net88 SE net92 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net88 D net76 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 net76 E net100 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t16 net84 nmen net100 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 net84 s net88 VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g8_MXNA1 nmen E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN13 nm cn net88 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNOE nm c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI40_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNA1 XI3_n1 m VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI3_MXNOE ns c XI3_n1 VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXNOE ns cn XI4_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI4_MXNA1 XI4_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mXI41_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t6 net127 SE VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
MX_t8 net111 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP7 net113 nmse net111 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 net113 D net131 VNW P18_DNW L=1.8e-07 W=7.7e-07
MX_t5 net131 nmen net127 VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP9 net105 E net127 VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP10 net105 s net113 VNW P18_DNW L=1.8e-07 W=7.7e-07
mX_g8_MXPA1 nmen E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP11 nm c net113 VNW P18_DNW L=1.8e-07 W=7.7e-07
mXI0_MXPOEN nm cn XI0_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXPA1 XI0_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI40_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI3_MXPA1 XI3_p1 m VDD VNW P18_DNW L=1.8e-07 W=6.3e-07
mXI3_MXPOEN ns cn XI3_p1 VNW P18_DNW L=1.8e-07 W=6.3e-07
mXI4_MXPOEN ns c XI4_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI4_MXPA1 XI4_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.3e-07
mXI41_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT SEDFF_X2_A7TR Q QN VDD VNW VPW VSS CK D E SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net180 nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN11 net187 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN12 net190 SE net187 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net190 D net181 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 net181 E net180 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t16 net196 nmen net180 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 net196 s net190 VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g8_MXNA1 nmen E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN13 nm cn net190 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNOE nm c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI40_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNA1 XI3_n1 m VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI3_MXNOE ns c XI3_n1 VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI4_MXNOE ns cn XI4_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI4_MXNA1 XI4_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI41_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t6 net85 SE VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
MX_t8 net97 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP7 net96 nmse net97 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 net96 D net91 VNW P18_DNW L=1.8e-07 W=7.7e-07
MX_t5 net91 nmen net85 VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP9 net88 E net85 VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP10 net88 s net96 VNW P18_DNW L=1.8e-07 W=7.7e-07
mX_g8_MXPA1 nmen E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP11 nm c net96 VNW P18_DNW L=1.8e-07 W=7.7e-07
mXI0_MXPOEN nm cn XI0_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXPA1 XI0_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI40_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI3_MXPA1 XI3_p1 m VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI3_MXPOEN ns cn XI3_p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI4_MXPOEN ns c XI4_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI4_MXPA1 XI4_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=5.5e-07
mXI41_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SEDFF_X4_A7TR Q QN VDD VNW VPW VSS CK D E SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net100 nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN11 net92 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN12 net88 SE net92 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net88 D net76 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 net76 E net100 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t16 net84 nmen net100 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 net84 s net88 VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g8_MXNA1 nmen E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN13 nm cn net88 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNOE nm c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mXI40_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNA1 XI3_n1 m VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mXI3_MXNOE ns c XI3_n1 VPW N18_DNW L=1.8e-07 W=8.1e-07
mXI4_MXNOE ns cn XI4_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI4_MXNA1 XI4_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI41_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI41_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t6 net127 SE VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
MX_t8 net111 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP7 net113 nmse net111 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 net113 D net131 VNW P18_DNW L=1.8e-07 W=7.7e-07
MX_t5 net131 nmen net127 VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP9 net105 E net127 VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP10 net105 s net113 VNW P18_DNW L=1.8e-07 W=7.7e-07
mX_g8_MXPA1 nmen E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP11 nm c net113 VNW P18_DNW L=1.8e-07 W=7.7e-07
mXI0_MXPOEN nm cn XI0_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXPA1 XI0_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI40_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI3_MXPA1 XI3_p1 m VDD VNW P18_DNW L=1.8e-07 W=1.2e-06
mXI3_MXPOEN ns cn XI3_p1 VNW P18_DNW L=1.8e-07 W=1.2e-06
mXI4_MXPOEN ns c XI4_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI4_MXPA1 XI4_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=8.8e-07
mXI41_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI41_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SMDFFHQ_X1_A7TR Q VDD VNW VPW VSS CK D0 D1 S0 SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI24_MXNA1 XI24_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI24_MXNOE nmsi SE XI24_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t8 nmsi nn1 d1n VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g13_MXNA1 d1n D1 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g8_MXNA1 nn1 n1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 n1 S0 net119 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 net119 nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 n2 SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 n2 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 nn2 n2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t11 nmsi n2 d0n VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g16_MXNA1 d0n D0 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
MX_t13 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
MXN4 VSS cn net107 VPW N18_DNW L=1.8e-07 W=4.7e-07
MX_t2 m nmsi net107 VPW N18_DNW L=1.8e-07 W=4.7e-07
mXI23_MXNOE m c XI23_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI23_MXNA1 XI23_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
MX_t0 ns c nm VPW N18_DNW L=1.8e-07 W=5.2e-07
mXI22_MXNOE ns cn XI22_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI22_MXNA1 XI22_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI24_MXPA1 XI24_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI24_MXPOEN nmsi nmse XI24_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g13_MXPA1 d1n D1 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
MX_t9 d1n n1 nmsi VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g8_MXPA1 nn1 n1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t38 VDD S0 n1 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 VDD nmse n1 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t43 VDD SE net85 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP1 net85 S0 n2 VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g6_MXPA1 nn2 n2 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 d0n nn2 nmsi VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g16_MXPA1 d0n D0 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t22 VDD CK net085 VNW P18_DNW L=1.8e-07 W=7.8e-07
MXP0 cn c net085 VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.01e-06
MX_t3i2 net060 c VDD VNW P18_DNW L=1.8e-07 W=7.1e-07
MXP3 m nmsi net060 VNW P18_DNW L=1.8e-07 W=7.1e-07
mXI23_MXPOEN m cn XI23_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI23_MXPA1 XI23_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.04e-06
MX_t1 nm cn ns VNW P18_DNW L=1.8e-07 W=1.04e-06
mXI22_MXPOEN ns c XI22_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI22_MXPA1 XI22_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT SMDFFHQ_X2_A7TR Q VDD VNW VPW VSS CK D0 D1 S0 SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI24_MXNA1 XI24_n1 SI VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI24_MXNOE nmsi SE XI24_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t8 nmsi nn1 d1n VPW N18_DNW L=1.8e-07 W=4.8e-07
mX_g13_MXNA1 d1n D1 VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
mX_g8_MXNA1 nn1 n1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 n1 S0 net119 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 net119 nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 n2 SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 n2 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 nn2 n2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t11 nmsi n2 d0n VPW N18_DNW L=1.8e-07 W=4.8e-07
mX_g16_MXNA1 d0n D0 VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
MX_t13 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN4 VSS cn net107 VPW N18_DNW L=1.8e-07 W=6e-07
MX_t2 m nmsi net107 VPW N18_DNW L=1.8e-07 W=6e-07
mXI23_MXNOE m c XI23_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI23_MXNA1 XI23_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
MX_t0 ns c nm VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI22_MXNOE ns cn XI22_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI22_MXNA1 XI22_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI24_MXPA1 XI24_p1 SI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI24_MXPOEN nmsi nmse XI24_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g13_MXPA1 d1n D1 VDD VNW P18_DNW L=1.8e-07 W=7.2e-07
MX_t9 d1n n1 nmsi VNW P18_DNW L=1.8e-07 W=7.2e-07
mX_g8_MXPA1 nn1 n1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t38 VDD S0 n1 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 VDD nmse n1 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t43 VDD SE net85 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP1 net85 S0 n2 VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g6_MXPA1 nn2 n2 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 d0n nn2 nmsi VNW P18_DNW L=1.8e-07 W=7.2e-07
mX_g16_MXPA1 d0n D0 VDD VNW P18_DNW L=1.8e-07 W=7.2e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t22 VDD CK net085 VNW P18_DNW L=1.8e-07 W=7.8e-07
MXP0 cn c net085 VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
MX_t3i2 net060 c VDD VNW P18_DNW L=1.8e-07 W=9.5e-07
MXP3 m nmsi net060 VNW P18_DNW L=1.8e-07 W=9.5e-07
mXI23_MXPOEN m cn XI23_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI23_MXPA1 XI23_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.45e-06
MX_t1 nm cn ns VNW P18_DNW L=1.8e-07 W=1.39e-06
mXI22_MXPOEN ns c XI22_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI22_MXPA1 XI22_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SMDFFHQ_X4_A7TR Q VDD VNW VPW VSS CK D0 D1 S0 SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI24_MXNA1 XI24_n1 SI VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI24_MXNOE nmsi SE XI24_n1 VPW N18_DNW L=1.8e-07 W=4.2e-07
MX_t8 nmsi nn1 d1n VPW N18_DNW L=1.8e-07 W=7.2e-07
mX_g13_MXNA1 d1n D1 VSS VPW N18_DNW L=1.8e-07 W=7.2e-07
mX_g8_MXNA1 nn1 n1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 n1 S0 net119 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 net119 nmse VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 n2 SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 n2 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 nn2 n2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t11 nmsi n2 d0n VPW N18_DNW L=1.8e-07 W=8.7e-07
mX_g16_MXNA1 d0n D0 VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
MX_t13 cn CK VSS VPW N18_DNW L=1.8e-07 W=4.6e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
MXN4_2 VSS cn net107__2 VPW N18_DNW L=1.8e-07 W=5.9e-07
MX_t2_2 m nmsi net107__2 VPW N18_DNW L=1.8e-07 W=4.6e-07
MX_t2 m nmsi net107 VPW N18_DNW L=1.8e-07 W=4.6e-07
MXN4 VSS cn net107 VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI23_MXNOE m c XI23_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI23_MXNA1 XI23_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mX_g7_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
MX_t0 ns c nm VPW N18_DNW L=1.8e-07 W=6.9e-07
MX_t0_2 ns c nm VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI22_MXNOE ns cn XI22_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI22_MXNA1 XI22_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI24_MXPA1 XI24_p1 SI VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI24_MXPOEN nmsi nmse XI24_p1 VNW P18_DNW L=1.8e-07 W=6.5e-07
mX_g13_MXPA1 d1n D1 VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
MX_t9 d1n n1 nmsi VNW P18_DNW L=1.8e-07 W=1.28e-06
mX_g8_MXPA1 nn1 n1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t38 VDD S0 n1 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 VDD nmse n1 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t43 VDD SE net85 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP1 net85 S0 n2 VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g6_MXPA1 nn2 n2 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 d0n nn2 nmsi VNW P18_DNW L=1.8e-07 W=1.3e-06
mX_g16_MXPA1 d0n D0 VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=5.8e-07
MX_t22 VDD CK net085 VNW P18_DNW L=1.8e-07 W=1.3e-06
MXP0 cn c net085 VNW P18_DNW L=1.8e-07 W=1.3e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
MX_t3i2_2 net060__2 c VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
MXP3_2 m nmsi net060__2 VNW P18_DNW L=1.8e-07 W=8.5e-07
MXP3 m nmsi net060 VNW P18_DNW L=1.8e-07 W=8.5e-07
MX_t3i2 net060 c VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
mXI23_MXPOEN m cn XI23_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI23_MXPA1 XI23_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.38e-06
mX_g7_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=1.38e-06
MX_t1 nm cn ns VNW P18_DNW L=1.8e-07 W=1.25e-06
MX_t1_2 nm cn ns VNW P18_DNW L=1.8e-07 W=1.25e-06
mXI22_MXPOEN ns c XI22_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI22_MXPA1 XI22_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT SMDFFHQ_X8_A7TR Q VDD VNW VPW VSS CK D0 D1 S0 SE SI
mX_g9_MXNA1 nmse SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI24_MXNA1 XI24_n1 SI VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mXI24_MXNOE nmsi SE XI24_n1 VPW N18_DNW L=1.8e-07 W=8.1e-07
MX_t8 nmsi nn1 d1n VPW N18_DNW L=1.8e-07 W=1.25e-06
mX_g13_MXNA1 d1n D1 VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mX_g13_MXNA1_2 d1n D1 VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mX_g8_MXNA1 nn1 n1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 n1 S0 net119 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN3 net119 nmse VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN1 n2 SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 n2 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 nn2 n2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t11 nmsi n2 d0n VPW N18_DNW L=1.8e-07 W=8.2e-07
MX_t11_2 nmsi n2 d0n VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g16_MXNA1 d0n D0 VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g16_MXNA1_2 d0n D0 VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
MX_t2_2 m nmsi net107__2 VPW N18_DNW L=1.8e-07 W=6.3e-07
MXN4_2 VSS cn net107__2 VPW N18_DNW L=1.8e-07 W=6.3e-07
MXN4_3 VSS cn net107__3 VPW N18_DNW L=1.8e-07 W=6.3e-07
MX_t2_3 m nmsi net107__3 VPW N18_DNW L=1.8e-07 W=6.3e-07
MX_t2 m nmsi net107 VPW N18_DNW L=1.8e-07 W=6.9e-07
MXN4 VSS cn net107 VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI23_MXNOE m c XI23_n1 VPW N18_DNW L=1.8e-07 W=2.9e-07
mXI23_MXNA1 XI23_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=9.1e-07
mX_g7_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=9.1e-07
mX_g7_MXNA1_3 nm m VSS VPW N18_DNW L=1.8e-07 W=9.1e-07
MX_t13 cn CK VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
mX_g10_MXNA1_2 c nck VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
MX_t0 ns c nm VPW N18_DNW L=1.8e-07 W=8.7e-07
MX_t0_2 ns c nm VPW N18_DNW L=1.8e-07 W=8.6e-07
MX_t0_3 ns c nm VPW N18_DNW L=1.8e-07 W=8.6e-07
mXI22_MXNOE ns cn XI22_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI22_MXNA1 XI22_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_3 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_4 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXPA1 nmse SE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI24_MXPA1_2 XI24_p1__2 SI VDD VNW P18_DNW L=1.8e-07 W=7e-07
mXI24_MXPOEN_2 nmsi nmse XI24_p1__2 VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI24_MXPOEN nmsi nmse XI24_p1 VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI24_MXPA1 XI24_p1 SI VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g13_MXPA1 d1n D1 VDD VNW P18_DNW L=1.8e-07 W=8.9e-07
mX_g13_MXPA1_2 d1n D1 VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
MX_t9 d1n n1 nmsi VNW P18_DNW L=1.8e-07 W=1.23e-06
MX_t9_2 d1n n1 nmsi VNW P18_DNW L=1.8e-07 W=1.23e-06
mX_g8_MXPA1 nn1 n1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t38 VDD S0 n1 VNW P18_DNW L=1.8e-07 W=4.5e-07
MXP2 VDD nmse n1 VNW P18_DNW L=1.8e-07 W=4.5e-07
MX_t43 VDD SE net85 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP1 net85 S0 n2 VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g6_MXPA1 nn2 n2 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 d0n nn2 nmsi VNW P18_DNW L=1.8e-07 W=1.23e-06
MX_t10_2 d0n nn2 nmsi VNW P18_DNW L=1.8e-07 W=1.23e-06
mX_g16_MXPA1 d0n D0 VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
mX_g16_MXPA1_2 d0n D0 VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
MXP3_2 m nmsi net060__2 VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t3i2_2 net060__2 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t3i2_3 net060__3 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP3_3 m nmsi net060__3 VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP3 m nmsi net060 VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t3i2 net060 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mXI23_MXPOEN m cn XI23_p1 VNW P18_DNW L=1.8e-07 W=4.3e-07
mXI23_MXPA1 XI23_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.3e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g7_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g7_MXPA1_3 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g7_MXPA1_4 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t22_2 VDD CK net085__2 VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP0_2 cn c net085__2 VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP0 cn c net085 VNW P18_DNW L=1.8e-07 W=1.19e-06
MX_t22 VDD CK net085 VNW P18_DNW L=1.8e-07 W=1.19e-06
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=1.03e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t1 nm cn ns VNW P18_DNW L=1.8e-07 W=1.27e-06
MX_t1_2 nm cn ns VNW P18_DNW L=1.8e-07 W=1.28e-06
MX_t1_3 nm cn ns VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI22_MXPOEN ns c XI22_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI22_MXPA1 XI22_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_3 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_4 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT TBUF_X12_A7TR Y VDD VNW VPW VSS A OE
mX_g0_MXNA1 nmen OE VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
MXN4 net31 nmen VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
MXN3 nmin OE net31 VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN3_2 nmin OE net31 VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN0 net31 A VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN0_2 net31 A VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN0_3 net31 A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
MXN2 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
MXN2_2 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
MXN2_3 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
MXN2_4 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_5 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_6 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXPA1 nmen OE VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
MXP4 nmin OE VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
MXP5 nmin nmen net31 VNW P18_DNW L=1.8e-07 W=5.1e-07
MXP5_2 nmin nmen net31 VNW P18_DNW L=1.8e-07 W=1.01e-06
MXP0 nmin A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
MXP0_2 nmin A VDD VNW P18_DNW L=1.8e-07 W=1.04e-06
MXP0_3 nmin A VDD VNW P18_DNW L=1.8e-07 W=1.04e-06
MXP2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2_2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2_3 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2_4 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_5 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_6 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT TBUF_X16_A7TR Y VDD VNW VPW VSS A OE
mX_g0_MXNA1 nmen OE VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN4 net31 nmen VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
MXN3 nmin OE net31 VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN3_2 nmin OE net31 VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN0 net31 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN0_2 net31 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN0_3 net31 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
MXN2_2 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
MXN2_3 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
MXN2_4 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_5 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_6 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_7 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_8 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXPA1 nmen OE VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
MXP4 nmin OE VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP5 nmin nmen net31 VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP5_2 nmin nmen net31 VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP0 nmin A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP0_2 nmin A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP0_3 nmin A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2_2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2_3 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2_4 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_5 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_6 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_7 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_8 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT TBUF_X1_A7TR Y VDD VNW VPW VSS A OE
mX_g0_MXNA1 nmen OE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net31 nmen VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 nmin OE net31 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 net31 A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 Y net31 VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g0_MXPA1 nmen OE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 nmin OE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 nmin nmen net31 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 nmin A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT TBUF_X20_A7TR Y VDD VNW VPW VSS A OE
mX_g0_MXNA1 nmen OE VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
MXN4 net31 nmen VSS VPW N18_DNW L=1.8e-07 W=5.5e-07
MXN4_2 net31 nmen VSS VPW N18_DNW L=1.8e-07 W=5.5e-07
MXN3 nmin OE net31 VPW N18_DNW L=1.8e-07 W=8.6e-07
MXN3_2 nmin OE net31 VPW N18_DNW L=1.8e-07 W=8.6e-07
MXN0 net31 A VSS VPW N18_DNW L=1.8e-07 W=8.6e-07
MXN0_2 net31 A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN0_3 net31 A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN0_4 net31 A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MXN2 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
MXN2_2 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
MXN2_3 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_4 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_5 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_6 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_7 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_8 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_9 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_10 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXPA1 nmen OE VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
MXP4 nmin OE VDD VNW P18_DNW L=1.8e-07 W=8.2e-07
MXP4_2 nmin OE VDD VNW P18_DNW L=1.8e-07 W=8.2e-07
MXP5 nmin nmen net31 VNW P18_DNW L=1.8e-07 W=1.13e-06
MXP5_2 nmin nmen net31 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP0 nmin A VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
MXP0_2 nmin A VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
MXP0_3 nmin A VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
MXP0_4 nmin A VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
MXP2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2_2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2_3 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_4 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_5 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_6 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_7 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_8 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_9 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_10 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT TBUF_X24_A7TR Y VDD VNW VPW VSS A OE
mX_g0_MXNA1 nmen OE VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN4 net31 nmen VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
MXN4_2 net31 nmen VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
MXN3 nmin OE net31 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN3_2 nmin OE net31 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN0 net31 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN0_2 net31 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN0_3 net31 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN0_4 net31 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
MXN2_2 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
MXN2_3 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_4 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_5 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_6 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_7 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_8 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_9 Y net31 VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
MXN2_10 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_11 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN2_12 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXPA1 nmen OE VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP4 nmin OE VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
MXP4_2 nmin OE VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
MXP5 nmin nmen net31 VNW P18_DNW L=1.8e-07 W=1.13e-06
MXP5_2 nmin nmen net31 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP0 nmin A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP0_2 nmin A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP0_3 nmin A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP0_4 nmin A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2_2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2_3 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_4 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_5 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_6 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_7 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_8 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_9 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_10 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_11 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP2_12 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT TBUF_X2_A7TR Y VDD VNW VPW VSS A OE
mX_g0_MXNA1 nmen OE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net31 nmen VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 nmin OE net31 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 net31 A VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
MXN2 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g0_MXPA1 nmen OE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 nmin OE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 nmin nmen net31 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 nmin A VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
MXP2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
.ends


.SUBCKT TBUF_X3_A7TR Y VDD VNW VPW VSS A OE
mX_g0_MXNA1 nmen OE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net31 nmen VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 nmin OE net31 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 net31 A VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN2 Y net31 VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
MXN2_2 Y net31 VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mX_g0_MXPA1 nmen OE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 nmin OE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 nmin nmen net31 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 nmin A VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
MXP2_2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
.ends


.SUBCKT TBUF_X4_A7TR Y VDD VNW VPW VSS A OE
mX_g0_MXNA1 nmen OE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net31 nmen VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 nmin OE net31 VPW N18_DNW L=1.8e-07 W=3.4e-07
MXN0 net31 A VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN2 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
MXN2_2 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
mX_g0_MXPA1 nmen OE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 nmin OE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 nmin nmen net31 VNW P18_DNW L=1.8e-07 W=5.1e-07
MXP0 nmin A VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2_2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
.ends


.SUBCKT TBUF_X6_A7TR Y VDD VNW VPW VSS A OE
mX_g0_MXNA1 nmen OE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net31 nmen VSS VPW N18_DNW L=1.8e-07 W=3.3e-07
MXN3 nmin OE net31 VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN0 net31 A VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN0_2 net31 A VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN2 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
MXN2_2 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
MXN2_3 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
mX_g0_MXPA1 nmen OE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 nmin OE VDD VNW P18_DNW L=1.8e-07 W=5e-07
MXP5 nmin nmen net31 VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP0 nmin A VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
MXP0_2 nmin A VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
MXP2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2_2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2_3 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
.ends


.SUBCKT TBUF_X8_A7TR Y VDD VNW VPW VSS A OE
mX_g0_MXNA1 nmen OE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net31 nmen VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN3 nmin OE net31 VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN0 net31 A VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN0_2 net31 A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
MXN2 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
MXN2_2 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
MXN2_3 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
MXN2_4 Y net31 VSS VPW N18_DNW L=1.8e-07 W=8e-07
mX_g0_MXPA1 nmen OE VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 nmin OE VDD VNW P18_DNW L=1.8e-07 W=5.8e-07
MXP5 nmin nmen net31 VNW P18_DNW L=1.8e-07 W=8.9e-07
MXP0 nmin A VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP0_2 nmin A VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2_2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2_3 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP2_4 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
.ends


.SUBCKT TIEHI_A7TR Y VDD VNW VPW VSS
MX_sc_n_i2 net17 net17 VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
MX_sc_p_i2 Y net17 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT TIELO_A7TR Y VDD VNW VPW VSS
MX_sc_n_i2 Y net4 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_sc_p_i2 net4 net4 VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
.ends


.SUBCKT TLATNCA_X12_A7TR ECK VDD VNW VPW VSS CK E
mX_g6_MXNA1 c CK VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g6_MXNA1_2 c CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g6_MXNA1_3 c CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g5_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=7e-07
mXI14_MXNA1_2 XI14_n1__2 E VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNOE_2 nm c XI14_n1__2 VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNOE_3 nm c XI14_n1__3 VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNA1_3 XI14_n1__3 E VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNA1_4 XI14_n1__4 E VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNOE_4 nm c XI14_n1__4 VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNOE nm c XI14_n1 VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNA1 XI14_n1 E VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI13_MXNOE nm cn XI13_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNA1 XI13_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA2_2 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1_2 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA2_3 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1_3 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mX_g6_MXPA1 c CK VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g6_MXPA1_2 c CK VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g6_MXPA1_3 c CK VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g5_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=1.06e-06
mXI14_MXPA1_2 XI14_p1__2 E VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI14_MXPOEN_2 nm cn XI14_p1__2 VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI14_MXPOEN_3 nm cn XI14_p1__3 VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI14_MXPA1_3 XI14_p1__3 E VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI14_MXPA1_4 XI14_p1__4 E VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI14_MXPOEN_4 nm cn XI14_p1__4 VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI14_MXPOEN nm cn XI14_p1 VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI14_MXPA1 XI14_p1 E VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI13_MXPOEN nm c XI13_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPA1 XI13_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2_2 XI1_p1__2 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_2 ECK nm XI1_p1__2 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_3 ECK nm XI1_p1__3 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_3 XI1_p1__3 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_4 XI1_p1__4 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_4 ECK nm XI1_p1__4 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_5 ECK nm XI1_p1__5 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_5 XI1_p1__5 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_6 XI1_p1__6 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_6 ECK nm XI1_p1__6 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1 ECK nm XI1_p1 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2 XI1_p1 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
.ends


.SUBCKT TLATNCA_X16_A7TR ECK VDD VNW VPW VSS CK E
mX_g6_MXNA1 c CK VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g6_MXNA1_2 c CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g6_MXNA1_3 c CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g6_MXNA1_4 c CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g5_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI14_MXNA1_2 XI14_n1__2 E VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI14_MXNOE_2 nm c XI14_n1__2 VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI14_MXNOE_3 nm c XI14_n1__3 VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI14_MXNA1_3 XI14_n1__3 E VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI14_MXNA1_4 XI14_n1__4 E VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI14_MXNOE_4 nm c XI14_n1__4 VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI14_MXNOE_5 nm c XI14_n1__5 VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI14_MXNA1_5 XI14_n1__5 E VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI14_MXNA1_6 XI14_n1__6 E VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI14_MXNOE_6 nm c XI14_n1__6 VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI14_MXNOE nm c XI14_n1 VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI14_MXNA1 XI14_n1 E VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI13_MXNOE nm cn XI13_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNA1 XI13_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 ECK c VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA2_2 ECK c VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1 ECK nm VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_2 ECK nm VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA2_3 ECK c VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA2_4 ECK c VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_3 ECK nm VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_4 ECK nm VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_5 ECK nm VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA2_5 ECK c VSS VPW N18_DNW L=1.8e-07 W=6e-07
mX_g6_MXPA1 c CK VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g6_MXPA1_2 c CK VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g6_MXPA1_3 c CK VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g6_MXPA1_4 c CK VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g5_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=1.29e-06
mXI14_MXPA1_2 XI14_p1__2 E VDD VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI14_MXPOEN_2 nm cn XI14_p1__2 VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI14_MXPOEN_3 nm cn XI14_p1__3 VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI14_MXPA1_3 XI14_p1__3 E VDD VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI14_MXPA1_4 XI14_p1__4 E VDD VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI14_MXPOEN_4 nm cn XI14_p1__4 VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI14_MXPOEN_5 nm cn XI14_p1__5 VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI14_MXPA1_5 XI14_p1__5 E VDD VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI14_MXPA1_6 XI14_p1__6 E VDD VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI14_MXPOEN_6 nm cn XI14_p1__6 VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI14_MXPOEN nm cn XI14_p1 VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI14_MXPA1 XI14_p1 E VDD VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI13_MXPOEN nm c XI13_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPA1 XI13_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2_2 XI1_p1__2 c VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA1_2 ECK nm XI1_p1__2 VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA1_3 ECK nm XI1_p1__3 VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA2_3 XI1_p1__3 c VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA2_4 XI1_p1__4 c VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA1_4 ECK nm XI1_p1__4 VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA1_5 ECK nm XI1_p1__5 VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA2_5 XI1_p1__5 c VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA2_6 XI1_p1__6 c VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA1_6 ECK nm XI1_p1__6 VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA1_7 ECK nm XI1_p1__7 VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA2_7 XI1_p1__7 c VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA2_8 XI1_p1__8 c VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA1_8 ECK nm XI1_p1__8 VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA1 ECK nm XI1_p1 VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA2 XI1_p1 c VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT TLATNCA_X20_A7TR ECK VDD VNW VPW VSS CK E
mX_g6_MXNA1 c CK VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g6_MXNA1_2 c CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g6_MXNA1_3 c CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g6_MXNA1_4 c CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g6_MXNA1_5 c CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g5_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=5.6e-07
mX_g5_MXNA1_2 cn c VSS VPW N18_DNW L=1.8e-07 W=5.6e-07
mXI14_MXNA1_2 XI14_n1__2 E VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNOE_2 nm c XI14_n1__2 VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNOE_3 nm c XI14_n1__3 VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNA1_3 XI14_n1__3 E VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNA1_4 XI14_n1__4 E VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNOE_4 nm c XI14_n1__4 VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNOE_5 nm c XI14_n1__5 VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNA1_5 XI14_n1__5 E VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNA1_6 XI14_n1__6 E VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNOE_6 nm c XI14_n1__6 VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNOE_7 nm c XI14_n1__7 VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNA1_7 XI14_n1__7 E VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNA1 XI14_n1 E VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI14_MXNOE nm c XI14_n1 VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI13_MXNOE nm cn XI13_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNA1 XI13_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 ECK c VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI1_MXNA2_2 ECK c VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI1_MXNA1 ECK nm VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI1_MXNA1_2 ECK nm VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI1_MXNA2_3 ECK c VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI1_MXNA2_4 ECK c VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI1_MXNA1_3 ECK nm VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI1_MXNA1_4 ECK nm VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI1_MXNA1_5 ECK nm VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI1_MXNA2_5 ECK c VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI1_MXNA2_6 ECK c VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI1_MXNA1_6 ECK nm VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g6_MXPA1 c CK VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g6_MXPA1_2 c CK VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g6_MXPA1_3 c CK VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g6_MXPA1_4 c CK VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g6_MXPA1_5 c CK VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g5_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=8.4e-07
mX_g5_MXPA1_2 cn c VDD VNW P18_DNW L=1.8e-07 W=8.4e-07
mXI14_MXPA1_2 XI14_p1__2 E VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
mXI14_MXPOEN_2 nm cn XI14_p1__2 VNW P18_DNW L=1.8e-07 W=1.18e-06
mXI14_MXPOEN_3 nm cn XI14_p1__3 VNW P18_DNW L=1.8e-07 W=1.18e-06
mXI14_MXPA1_3 XI14_p1__3 E VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
mXI14_MXPA1_4 XI14_p1__4 E VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
mXI14_MXPOEN_4 nm cn XI14_p1__4 VNW P18_DNW L=1.8e-07 W=1.18e-06
mXI14_MXPOEN_5 nm cn XI14_p1__5 VNW P18_DNW L=1.8e-07 W=1.18e-06
mXI14_MXPA1_5 XI14_p1__5 E VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
mXI14_MXPA1_6 XI14_p1__6 E VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
mXI14_MXPOEN_6 nm cn XI14_p1__6 VNW P18_DNW L=1.8e-07 W=1.18e-06
mXI14_MXPOEN_7 nm cn XI14_p1__7 VNW P18_DNW L=1.8e-07 W=1.18e-06
mXI14_MXPA1_7 XI14_p1__7 E VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
mXI14_MXPA1 XI14_p1 E VDD VNW P18_DNW L=1.8e-07 W=1.14e-06
mXI14_MXPOEN nm cn XI14_p1 VNW P18_DNW L=1.8e-07 W=1.14e-06
mXI13_MXPOEN nm c XI13_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPA1 XI13_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2_2 XI1_p1__2 c VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA1_2 ECK nm XI1_p1__2 VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA1_3 ECK nm XI1_p1__3 VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA2_3 XI1_p1__3 c VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA2_4 XI1_p1__4 c VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA1_4 ECK nm XI1_p1__4 VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA1_5 ECK nm XI1_p1__5 VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA2_5 XI1_p1__5 c VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA2_6 XI1_p1__6 c VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA1_6 ECK nm XI1_p1__6 VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA1_7 ECK nm XI1_p1__7 VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA2_7 XI1_p1__7 c VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA2_8 XI1_p1__8 c VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA1_8 ECK nm XI1_p1__8 VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA1_9 ECK nm XI1_p1__9 VNW P18_DNW L=1.8e-07 W=9e-07
mXI1_MXPA2_9 XI1_p1__9 c VDD VNW P18_DNW L=1.8e-07 W=9e-07
mXI1_MXPA2_10 XI1_p1__10 c VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA1_10 ECK nm XI1_p1__10 VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA1 ECK nm XI1_p1 VNW P18_DNW L=1.8e-07 W=1.3e-06
mXI1_MXPA2 XI1_p1 c VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
.ends


.SUBCKT TLATNCA_X2_A7TR ECK VDD VNW VPW VSS CK E
mX_g6_MXNA1 c CK VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g5_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI14_MXNA1 XI14_n1 E VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI14_MXNOE nm c XI14_n1 VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI13_MXNOE nm cn XI13_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI13_MXNA1 XI13_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 ECK c VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXNA1 ECK nm VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g6_MXPA1 c CK VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g5_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI14_MXPA1 XI14_p1 E VDD VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI14_MXPOEN nm cn XI14_p1 VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI13_MXPOEN nm c XI13_p1 VNW P18_DNW L=1.8e-07 W=3.7e-07
mXI13_MXPA1 XI13_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2 XI1_p1 c VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 ECK nm XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT TLATNCA_X3_A7TR ECK VDD VNW VPW VSS CK E
mX_g6_MXNA1 c CK VSS VPW N18_DNW L=1.8e-07 W=7.8e-07
mX_g5_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI14_MXNA1 XI14_n1 E VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mXI14_MXNOE nm c XI14_n1 VPW N18_DNW L=1.8e-07 W=8.1e-07
mXI13_MXNOE nm cn XI13_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI13_MXNA1 XI13_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 ECK c VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
mXI1_MXNA1 ECK nm VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
mX_g6_MXPA1 c CK VDD VNW P18_DNW L=1.8e-07 W=1.17e-06
mX_g5_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI14_MXPA1 XI14_p1 E VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI14_MXPOEN nm cn XI14_p1 VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI13_MXPOEN nm c XI13_p1 VNW P18_DNW L=1.8e-07 W=3.7e-07
mXI13_MXPA1 XI13_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2_2 XI1_p1__2 c VDD VNW P18_DNW L=1.8e-07 W=6e-07
mXI1_MXPA1_2 ECK nm XI1_p1__2 VNW P18_DNW L=1.8e-07 W=6e-07
mXI1_MXPA1 ECK nm XI1_p1 VNW P18_DNW L=1.8e-07 W=6e-07
mXI1_MXPA2 XI1_p1 c VDD VNW P18_DNW L=1.8e-07 W=6e-07
.ends


.SUBCKT TLATNCA_X4_A7TR ECK VDD VNW VPW VSS CK E
mX_g6_MXNA1 c CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g5_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI14_MXNA1_2 XI14_n1__2 E VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
mXI14_MXNOE_2 nm c XI14_n1__2 VPW N18_DNW L=1.8e-07 W=6.3e-07
mXI14_MXNOE nm c XI14_n1 VPW N18_DNW L=1.8e-07 W=6.3e-07
mXI14_MXNA1 XI14_n1 E VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNA1 XI13_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNOE nm cn XI13_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA2 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mX_g6_MXPA1 c CK VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g5_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI14_MXPA1_2 XI14_p1__2 E VDD VNW P18_DNW L=1.8e-07 W=8.1e-07
mXI14_MXPOEN_2 nm cn XI14_p1__2 VNW P18_DNW L=1.8e-07 W=8.1e-07
mXI14_MXPOEN nm cn XI14_p1 VNW P18_DNW L=1.8e-07 W=9.3e-07
mXI14_MXPA1 XI14_p1 E VDD VNW P18_DNW L=1.8e-07 W=9.3e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPA1 XI13_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPOEN nm c XI13_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2_2 XI1_p1__2 c VDD VNW P18_DNW L=1.8e-07 W=8e-07
mXI1_MXPA1_2 ECK nm XI1_p1__2 VNW P18_DNW L=1.8e-07 W=8e-07
mXI1_MXPA1 ECK nm XI1_p1 VNW P18_DNW L=1.8e-07 W=8e-07
mXI1_MXPA2 XI1_p1 c VDD VNW P18_DNW L=1.8e-07 W=8e-07
.ends


.SUBCKT TLATNCA_X6_A7TR ECK VDD VNW VPW VSS CK E
mX_g6_MXNA1 c CK VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g6_MXNA1_2 c CK VSS VPW N18_DNW L=1.8e-07 W=8e-07
mX_g5_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI14_MXNA1_2 XI14_n1__2 E VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNOE_2 nm c XI14_n1__2 VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNOE nm c XI14_n1 VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXNA1 XI14_n1 E VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI13_MXNA1 XI13_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNOE nm cn XI13_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 ECK nm VSS VPW N18_DNW L=1.8e-07 W=4.7e-07
mXI1_MXNA2 ECK c VSS VPW N18_DNW L=1.8e-07 W=4.7e-07
mXI1_MXNA2_2 ECK c VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI1_MXNA1_2 ECK nm VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g6_MXPA1 c CK VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g6_MXPA1_2 c CK VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g5_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=6e-07
mXI14_MXPA1_2 XI14_p1__2 E VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI14_MXPOEN_2 nm cn XI14_p1__2 VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI14_MXPOEN nm cn XI14_p1 VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI14_MXPA1 XI14_p1 E VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI13_MXPOEN nm c XI13_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPA1 XI13_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2_2 XI1_p1__2 c VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 ECK nm XI1_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 ECK nm XI1_p1__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_3 XI1_p1__3 c VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2 XI1_p1 c VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 ECK nm XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT TLATNCA_X8_A7TR ECK VDD VNW VPW VSS CK E
mX_g6_MXNA1 c CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g6_MXNA1_2 c CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g5_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=5e-07
mXI14_MXNA1_2 XI14_n1__2 E VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI14_MXNOE_2 nm c XI14_n1__2 VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI14_MXNOE_3 nm c XI14_n1__3 VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI14_MXNA1_3 XI14_n1__3 E VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI14_MXNA1 XI14_n1 E VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI14_MXNOE nm c XI14_n1 VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI13_MXNOE nm cn XI13_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNA1 XI13_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 ECK nm VSS VPW N18_DNW L=1.8e-07 W=4.7e-07
mXI1_MXNA2 ECK c VSS VPW N18_DNW L=1.8e-07 W=4.7e-07
mXI1_MXNA2_2 ECK c VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXNA1_2 ECK nm VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXNA1_3 ECK nm VSS VPW N18_DNW L=1.8e-07 W=5.2e-07
mXI1_MXNA2_3 ECK c VSS VPW N18_DNW L=1.8e-07 W=5.2e-07
mX_g6_MXPA1 c CK VDD VNW P18_DNW L=1.8e-07 W=1.31e-06
mX_g6_MXPA1_2 c CK VDD VNW P18_DNW L=1.8e-07 W=1.31e-06
mX_g5_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=7.5e-07
mXI14_MXPA1_2 XI14_p1__2 E VDD VNW P18_DNW L=1.8e-07 W=1.05e-06
mXI14_MXPOEN_2 nm cn XI14_p1__2 VNW P18_DNW L=1.8e-07 W=1.05e-06
mXI14_MXPOEN_3 nm cn XI14_p1__3 VNW P18_DNW L=1.8e-07 W=1.05e-06
mXI14_MXPA1_3 XI14_p1__3 E VDD VNW P18_DNW L=1.8e-07 W=1.05e-06
mXI14_MXPA1 XI14_p1 E VDD VNW P18_DNW L=1.8e-07 W=1.05e-06
mXI14_MXPOEN nm cn XI14_p1 VNW P18_DNW L=1.8e-07 W=1.05e-06
mXI13_MXPOEN nm c XI13_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPA1 XI13_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2_2 XI1_p1__2 c VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 ECK nm XI1_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 ECK nm XI1_p1__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_3 XI1_p1__3 c VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_4 XI1_p1__4 c VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 ECK nm XI1_p1__4 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 ECK nm XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2 XI1_p1 c VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT TLATNSR_X1_A7TR Q QN VDD VNW VPW VSS D GN RN SN
mX_g3_MXNA1 nms SN VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
MX_t6 nm nms VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
MXN7 net048 D VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
MXN6 net052 RN net048 VPW N18_DNW L=1.8e-07 W=6.2e-07
MX_t13 nm c net052 VPW N18_DNW L=1.8e-07 W=6.2e-07
MX_t2 nm cn net98 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN8 net98 RN net101 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN9 VSS m net101 VPW N18_DNW L=1.8e-07 W=4.5e-07
mX_g4_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 c GN VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI47_MXNA1 Q nm VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI46_MXNA1 QN m VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g3_MXPA1 nms SN VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP11 nm nms net61 VNW P18_DNW L=1.8e-07 W=8.6e-07
MX_t14 net61 RN VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MX_t9 net083 D VDD VNW P18_DNW L=1.8e-07 W=9.3e-07
MXP9 net075 nms net083 VNW P18_DNW L=1.8e-07 W=9.3e-07
MXP10 nm cn net075 VNW P18_DNW L=1.8e-07 W=9.3e-07
MXP13 nm c net70 VNW P18_DNW L=1.8e-07 W=5.1e-07
MXP12 net70 nms net67 VNW P18_DNW L=1.8e-07 W=5.1e-07
MX_t5 VDD m net67 VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g4_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 c GN VDD VNW P18_DNW L=1.8e-07 W=5.8e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI47_MXPA1 Q nm VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI46_MXPA1 QN m VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT TLATNSR_X2_A7TR Q QN VDD VNW VPW VSS D GN RN SN
mX_g3_MXNA1 nms SN VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
MX_t6 nm nms VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN7_2 net048__2 D VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
MXN6_2 net052__2 RN net048__2 VPW N18_DNW L=1.8e-07 W=6.9e-07
MX_t13_2 nm c net052__2 VPW N18_DNW L=1.8e-07 W=5.4e-07
MX_t13 nm c net052 VPW N18_DNW L=1.8e-07 W=5.4e-07
MXN6 net052 RN net048 VPW N18_DNW L=1.8e-07 W=3.3e-07
MXN7 net048 D VSS VPW N18_DNW L=1.8e-07 W=3.3e-07
MX_t2 nm cn net98 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN8 net98 RN net101 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN9 VSS m net101 VPW N18_DNW L=1.8e-07 W=4.5e-07
mX_g4_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 c GN VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI47_MXNA1 Q nm VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI46_MXNA1 QN m VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXPA1 nms SN VDD VNW P18_DNW L=1.8e-07 W=9.6e-07
MXP11 nm nms net61 VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t14 net61 RN VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t9_2 net083__2 D VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP9_2 net075__2 nms net083__2 VNW P18_DNW L=1.8e-07 W=8e-07
MXP10_2 nm cn net075__2 VNW P18_DNW L=1.8e-07 W=8e-07
MXP10 nm cn net075 VNW P18_DNW L=1.8e-07 W=8e-07
MXP9 net075 nms net083 VNW P18_DNW L=1.8e-07 W=8e-07
MX_t9 net083 D VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP13 nm c net70 VNW P18_DNW L=1.8e-07 W=5.1e-07
MXP12 net70 nms net67 VNW P18_DNW L=1.8e-07 W=5.1e-07
MX_t5 VDD m net67 VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g4_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 c GN VDD VNW P18_DNW L=1.8e-07 W=5.9e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI47_MXPA1 Q nm VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI46_MXPA1 QN m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT TLATNSR_X4_A7TR Q QN VDD VNW VPW VSS D GN RN SN
mX_g3_MXNA1 nms SN VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g3_MXNA1_2 nms SN VSS VPW N18_DNW L=1.8e-07 W=6e-07
MX_t6 nm nms VSS VPW N18_DNW L=1.8e-07 W=6e-07
MX_t6_2 nm nms VSS VPW N18_DNW L=1.8e-07 W=6e-07
MXN7_2 net048__2 D VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
MXN6_2 net052__2 RN net048__2 VPW N18_DNW L=1.8e-07 W=6.9e-07
MX_t13_2 nm c net052__2 VPW N18_DNW L=1.8e-07 W=5.4e-07
MX_t13 nm c net052 VPW N18_DNW L=1.8e-07 W=5.4e-07
MXN6 net052 RN net048 VPW N18_DNW L=1.8e-07 W=3.3e-07
MXN7 net048 D VSS VPW N18_DNW L=1.8e-07 W=3.3e-07
MX_t2 nm cn net98 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN8 net98 RN net101 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN9 VSS m net101 VPW N18_DNW L=1.8e-07 W=4.5e-07
mX_g4_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=4.9e-07
mX_g5_MXNA1 c GN VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1_2 m nm VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI47_MXNA1 Q nm VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI47_MXNA1_2 Q nm VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI46_MXNA1 QN m VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI46_MXNA1_2 QN m VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXPA1 nms SN VDD VNW P18_DNW L=1.8e-07 W=9.1e-07
mX_g3_MXPA1_2 nms SN VDD VNW P18_DNW L=1.8e-07 W=9.1e-07
MXP11 nm nms net61 VNW P18_DNW L=1.8e-07 W=1.41e-06
MX_t14 net61 RN VDD VNW P18_DNW L=1.8e-07 W=1.41e-06
MX_t9_2 net083__2 D VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
MXP9_2 net075__2 nms net083__2 VNW P18_DNW L=1.8e-07 W=8.5e-07
MXP10_2 nm cn net075__2 VNW P18_DNW L=1.8e-07 W=8.5e-07
MXP10 nm cn net075 VNW P18_DNW L=1.8e-07 W=8.5e-07
MXP9 net075 nms net083 VNW P18_DNW L=1.8e-07 W=8.5e-07
MX_t9 net083 D VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
MXP13 nm c net70 VNW P18_DNW L=1.8e-07 W=5.1e-07
MXP12 net70 nms net67 VNW P18_DNW L=1.8e-07 W=5.1e-07
MX_t5 VDD m net67 VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g4_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
mX_g5_MXPA1 c GN VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1_2 m nm VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI47_MXPA1 Q nm VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI47_MXPA1_2 Q nm VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI46_MXPA1 QN m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI46_MXPA1_2 QN m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT TLATNTSCA_X12_A7TR ECK VDD VNW VPW VSS CK E SE
mX_g6_MXNA1 c CK VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
mX_g6_MXNA1_2 c CK VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g6_MXNA1_3 c CK VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
mX_g5_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=7e-07
mX_g8_MXNA1 nmsetin E VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g8_MXNA2 nmsetin SE VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g7_MXNA1 setin nmsetin VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g7_MXNA1_2 setin nmsetin VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g3_MXNA1_2 X_g3_n1__2 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_2 nm c X_g3_n1__2 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_3 nm c X_g3_n1__3 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_3 X_g3_n1__3 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_4 X_g3_n1__4 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_4 nm c X_g3_n1__4 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_5 nm c X_g3_n1__5 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_5 X_g3_n1__5 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_6 X_g3_n1__6 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_6 nm c X_g3_n1__6 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE nm c X_g3_n1 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1 X_g3_n1 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 XI7_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNOE nm cn XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA2 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA2_2 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1_2 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA2_3 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1_3 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mX_g6_MXPA1 c CK VDD VNW P18_DNW L=1.8e-07 W=1.27e-06
mX_g6_MXPA1_2 c CK VDD VNW P18_DNW L=1.8e-07 W=1.27e-06
mX_g6_MXPA1_3 c CK VDD VNW P18_DNW L=1.8e-07 W=1.27e-06
mX_g5_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=1.06e-06
mX_g8_MXPA1 nmsetin E X_g8_p1 VNW P18_DNW L=1.8e-07 W=1.01e-06
mX_g8_MXPA2 X_g8_p1 SE VDD VNW P18_DNW L=1.8e-07 W=1.01e-06
mX_g7_MXPA1 setin nmsetin VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g7_MXPA1_2 setin nmsetin VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g3_MXPA1_2 X_g3_p1__2 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_2 nm cn X_g3_p1__2 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_3 nm cn X_g3_p1__3 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_3 X_g3_p1__3 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_4 X_g3_p1__4 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_4 nm cn X_g3_p1__4 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_5 nm cn X_g3_p1__5 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_5 X_g3_p1__5 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_6 X_g3_p1__6 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_6 nm cn X_g3_p1__6 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN nm cn X_g3_p1 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1 X_g3_p1 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA1 XI7_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPOEN nm c XI7_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2_2 XI1_p1__2 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_2 ECK nm XI1_p1__2 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_3 ECK nm XI1_p1__3 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_3 XI1_p1__3 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_4 XI1_p1__4 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_4 ECK nm XI1_p1__4 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_5 ECK nm XI1_p1__5 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_5 XI1_p1__5 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2 XI1_p1 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1 ECK nm XI1_p1 VNW P18_DNW L=1.8e-07 W=1.26e-06
.ends


.SUBCKT TLATNTSCA_X16_A7TR ECK VDD VNW VPW VSS CK E SE
mX_g6_MXNA1 c CK VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
mX_g6_MXNA1_2 c CK VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
mX_g6_MXNA1_3 c CK VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g6_MXNA1_4 c CK VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
mX_g5_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g8_MXNA1 nmsetin E VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mX_g8_MXNA2 nmsetin SE VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mX_g7_MXNA1 setin nmsetin VSS VPW N18_DNW L=1.8e-07 W=8.6e-07
mX_g7_MXNA1_2 setin nmsetin VSS VPW N18_DNW L=1.8e-07 W=8.6e-07
mX_g3_MXNA1_2 X_g3_n1__2 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_2 nm c X_g3_n1__2 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_3 nm c X_g3_n1__3 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_3 X_g3_n1__3 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_4 X_g3_n1__4 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_4 nm c X_g3_n1__4 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_5 nm c X_g3_n1__5 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_5 X_g3_n1__5 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_6 X_g3_n1__6 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_6 nm c X_g3_n1__6 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_7 nm c X_g3_n1__7 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_7 X_g3_n1__7 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_8 X_g3_n1__8 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_8 nm c X_g3_n1__8 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE nm c X_g3_n1 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1 X_g3_n1 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 XI7_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNOE nm cn XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA2 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA2_2 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1_2 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA2_3 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1_3 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA2_4 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1_4 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mX_g6_MXPA1 c CK VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g6_MXPA1_2 c CK VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g6_MXPA1_3 c CK VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g6_MXPA1_4 c CK VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g5_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g8_MXPA1 nmsetin E X_g8_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g8_MXPA2 X_g8_p1 SE VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g7_MXPA1 setin nmsetin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g7_MXPA1_2 setin nmsetin VDD VNW P18_DNW L=1.8e-07 W=1.24e-06
mX_g3_MXPA1_2 X_g3_p1__2 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_2 nm cn X_g3_p1__2 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_3 nm cn X_g3_p1__3 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_3 X_g3_p1__3 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_4 X_g3_p1__4 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_4 nm cn X_g3_p1__4 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_5 nm cn X_g3_p1__5 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_5 X_g3_p1__5 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_6 X_g3_p1__6 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_6 nm cn X_g3_p1__6 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_7 nm cn X_g3_p1__7 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_7 X_g3_p1__7 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_8 X_g3_p1__8 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_8 nm cn X_g3_p1__8 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN nm cn X_g3_p1 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1 X_g3_p1 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA1 XI7_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPOEN nm c XI7_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2_2 XI1_p1__2 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_2 ECK nm XI1_p1__2 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_3 ECK nm XI1_p1__3 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_3 XI1_p1__3 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_4 XI1_p1__4 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_4 ECK nm XI1_p1__4 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_5 ECK nm XI1_p1__5 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_5 XI1_p1__5 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_6 XI1_p1__6 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_6 ECK nm XI1_p1__6 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_7 ECK nm XI1_p1__7 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_7 XI1_p1__7 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2 XI1_p1 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1 ECK nm XI1_p1 VNW P18_DNW L=1.8e-07 W=1.26e-06
.ends


.SUBCKT TLATNTSCA_X20_A7TR ECK VDD VNW VPW VSS CK E SE
mX_g6_MXNA1 c CK VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
mX_g6_MXNA1_2 c CK VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g6_MXNA1_3 c CK VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
mX_g6_MXNA1_4 c CK VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
mX_g6_MXNA1_5 c CK VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
mX_g5_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=5.6e-07
mX_g5_MXNA1_2 cn c VSS VPW N18_DNW L=1.8e-07 W=5.6e-07
mX_g8_MXNA1 nmsetin E VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g8_MXNA2 nmsetin SE VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g7_MXNA1 setin nmsetin VSS VPW N18_DNW L=1.8e-07 W=7.1e-07
mX_g7_MXNA1_2 setin nmsetin VSS VPW N18_DNW L=1.8e-07 W=7.1e-07
mX_g7_MXNA1_3 setin nmsetin VSS VPW N18_DNW L=1.8e-07 W=7.1e-07
mX_g3_MXNA1_2 X_g3_n1__2 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_2 nm c X_g3_n1__2 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_3 nm c X_g3_n1__3 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_3 X_g3_n1__3 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_4 X_g3_n1__4 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_4 nm c X_g3_n1__4 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_5 nm c X_g3_n1__5 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_5 X_g3_n1__5 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_6 X_g3_n1__6 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_6 nm c X_g3_n1__6 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_7 nm c X_g3_n1__7 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_7 X_g3_n1__7 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_8 X_g3_n1__8 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_8 nm c X_g3_n1__8 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE nm c X_g3_n1 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1 X_g3_n1 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 XI7_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNOE nm cn XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA2 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA2_2 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1_2 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA2_3 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1_3 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA2_4 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1_4 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA2_5 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1_5 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mX_g6_MXPA1 c CK VDD VNW P18_DNW L=1.8e-07 W=1.25e-06
mX_g6_MXPA1_2 c CK VDD VNW P18_DNW L=1.8e-07 W=1.25e-06
mX_g6_MXPA1_3 c CK VDD VNW P18_DNW L=1.8e-07 W=1.25e-06
mX_g6_MXPA1_4 c CK VDD VNW P18_DNW L=1.8e-07 W=1.25e-06
mX_g6_MXPA1_5 c CK VDD VNW P18_DNW L=1.8e-07 W=1.25e-06
mX_g5_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=8.4e-07
mX_g5_MXPA1_2 cn c VDD VNW P18_DNW L=1.8e-07 W=8.4e-07
mX_g8_MXPA1 nmsetin E X_g8_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g8_MXPA2 X_g8_p1 SE VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g7_MXPA1 setin nmsetin VDD VNW P18_DNW L=1.8e-07 W=1.06e-06
mX_g7_MXPA1_2 setin nmsetin VDD VNW P18_DNW L=1.8e-07 W=1.06e-06
mX_g7_MXPA1_3 setin nmsetin VDD VNW P18_DNW L=1.8e-07 W=1.06e-06
mX_g3_MXPA1_2 X_g3_p1__2 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_2 nm cn X_g3_p1__2 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_3 nm cn X_g3_p1__3 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_3 X_g3_p1__3 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_4 X_g3_p1__4 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_4 nm cn X_g3_p1__4 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_5 nm cn X_g3_p1__5 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_5 X_g3_p1__5 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_6 X_g3_p1__6 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_6 nm cn X_g3_p1__6 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_7 nm cn X_g3_p1__7 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_7 X_g3_p1__7 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_8 X_g3_p1__8 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_8 nm cn X_g3_p1__8 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN nm cn X_g3_p1 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1 X_g3_p1 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA1 XI7_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPOEN nm c XI7_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2_2 XI1_p1__2 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_2 ECK nm XI1_p1__2 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_3 ECK nm XI1_p1__3 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_3 XI1_p1__3 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_4 XI1_p1__4 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_4 ECK nm XI1_p1__4 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_5 ECK nm XI1_p1__5 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_5 XI1_p1__5 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_6 XI1_p1__6 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_6 ECK nm XI1_p1__6 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_7 ECK nm XI1_p1__7 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_7 XI1_p1__7 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_8 XI1_p1__8 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_8 ECK nm XI1_p1__8 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1_9 ECK nm XI1_p1__9 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2_9 XI1_p1__9 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA2 XI1_p1 c VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPA1 ECK nm XI1_p1 VNW P18_DNW L=1.8e-07 W=1.26e-06
.ends


.SUBCKT TLATNTSCA_X2_A7TR ECK VDD VNW VPW VSS CK E SE
mX_g8_MXNA2 nmsetin SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g8_MXNA1 nmsetin E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 setin nmsetin VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mX_g6_MXNA1 c CK VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g5_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 X_g3_n1 setin VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mX_g3_MXNOE nm c X_g3_n1 VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI7_MXNOE nm cn XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNA1 XI7_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 ECK c VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXNA1 ECK nm VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g8_MXPA2 X_g8_p1 SE VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g8_MXPA1 nmsetin E X_g8_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g7_MXPA1 setin nmsetin VDD VNW P18_DNW L=1.8e-07 W=4.3e-07
mX_g6_MXPA1 c CK VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g5_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 X_g3_p1 setin VDD VNW P18_DNW L=1.8e-07 W=1.11e-06
mX_g3_MXPOEN nm cn X_g3_p1 VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI7_MXPOEN nm c XI7_p1 VNW P18_DNW L=1.8e-07 W=3.7e-07
mXI7_MXPA1 XI7_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2 XI1_p1 c VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 ECK nm XI1_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT TLATNTSCA_X3_A7TR ECK VDD VNW VPW VSS CK E SE
mX_g8_MXNA2 nmsetin SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g8_MXNA1 nmsetin E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 setin nmsetin VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
mX_g6_MXNA1 c CK VSS VPW N18_DNW L=1.8e-07 W=7.8e-07
mX_g5_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 X_g3_n1 setin VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mX_g3_MXNOE nm c X_g3_n1 VPW N18_DNW L=1.8e-07 W=8.1e-07
mXI7_MXNOE nm cn XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNA1 XI7_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 ECK c VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
mXI1_MXNA1 ECK nm VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
mX_g8_MXPA2 X_g8_p1 SE VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g8_MXPA1 nmsetin E X_g8_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g7_MXPA1 setin nmsetin VDD VNW P18_DNW L=1.8e-07 W=5.7e-07
mX_g6_MXPA1 c CK VDD VNW P18_DNW L=1.8e-07 W=1.17e-06
mX_g5_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 X_g3_p1 setin VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mX_g3_MXPOEN nm cn X_g3_p1 VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI7_MXPOEN nm c XI7_p1 VNW P18_DNW L=1.8e-07 W=3.7e-07
mXI7_MXPA1 XI7_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2_2 XI1_p1__2 c VDD VNW P18_DNW L=1.8e-07 W=6e-07
mXI1_MXPA1_2 ECK nm XI1_p1__2 VNW P18_DNW L=1.8e-07 W=6e-07
mXI1_MXPA1 ECK nm XI1_p1 VNW P18_DNW L=1.8e-07 W=6e-07
mXI1_MXPA2 XI1_p1 c VDD VNW P18_DNW L=1.8e-07 W=6e-07
.ends


.SUBCKT TLATNTSCA_X4_A7TR ECK VDD VNW VPW VSS CK E SE
mX_g6_MXNA1 c CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g5_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=3e-07
mX_g8_MXNA1 nmsetin E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g8_MXNA2 nmsetin SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 setin nmsetin VSS VPW N18_DNW L=1.8e-07 W=4.9e-07
mX_g3_MXNA1_2 X_g3_n1__2 setin VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
mX_g3_MXNOE_2 nm c X_g3_n1__2 VPW N18_DNW L=1.8e-07 W=6.3e-07
mX_g3_MXNOE nm c X_g3_n1 VPW N18_DNW L=1.8e-07 W=6.3e-07
mX_g3_MXNA1 X_g3_n1 setin VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 XI7_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNOE nm cn XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA2 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mX_g6_MXPA1 c CK VDD VNW P18_DNW L=1.8e-07 W=1.29e-06
mX_g5_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mX_g8_MXPA1 nmsetin E X_g8_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g8_MXPA2 X_g8_p1 SE VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g7_MXPA1 setin nmsetin VDD VNW P18_DNW L=1.8e-07 W=7.4e-07
mX_g3_MXPA1_2 X_g3_p1__2 setin VDD VNW P18_DNW L=1.8e-07 W=9.3e-07
mX_g3_MXPOEN_2 nm cn X_g3_p1__2 VNW P18_DNW L=1.8e-07 W=9.3e-07
mX_g3_MXPOEN nm cn X_g3_p1 VNW P18_DNW L=1.8e-07 W=9.3e-07
mX_g3_MXPA1 X_g3_p1 setin VDD VNW P18_DNW L=1.8e-07 W=9.3e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA1 XI7_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPOEN nm c XI7_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2_2 XI1_p1__2 c VDD VNW P18_DNW L=1.8e-07 W=8e-07
mXI1_MXPA1_2 ECK nm XI1_p1__2 VNW P18_DNW L=1.8e-07 W=8e-07
mXI1_MXPA1 ECK nm XI1_p1 VNW P18_DNW L=1.8e-07 W=8e-07
mXI1_MXPA2 XI1_p1 c VDD VNW P18_DNW L=1.8e-07 W=8e-07
.ends


.SUBCKT TLATNTSCA_X6_A7TR ECK VDD VNW VPW VSS CK E SE
mX_g6_MXNA1 c CK VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mX_g6_MXNA1_2 c CK VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g5_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g8_MXNA1 nmsetin E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g8_MXNA2 nmsetin SE VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 setin nmsetin VSS VPW N18_DNW L=1.8e-07 W=7e-07
mX_g3_MXNOE_2 nm c X_g3_n1__2 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_2 X_g3_n1__2 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_3 X_g3_n1__3 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_3 nm c X_g3_n1__3 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE nm c X_g3_n1 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1 X_g3_n1 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 XI7_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNOE nm cn XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA2 ECK c VSS VPW N18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXNA1 ECK nm VSS VPW N18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXNA2_2 ECK c VSS VPW N18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXNA1_2 ECK nm VSS VPW N18_DNW L=1.8e-07 W=5.6e-07
mX_g6_MXPA1 c CK VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g6_MXPA1_2 c CK VDD VNW P18_DNW L=1.8e-07 W=9.3e-07
mX_g5_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=5.4e-07
mX_g8_MXPA1 nmsetin E X_g8_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g8_MXPA2 X_g8_p1 SE VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g7_MXPA1 setin nmsetin VDD VNW P18_DNW L=1.8e-07 W=1.04e-06
mX_g3_MXPOEN_2 nm cn X_g3_p1__2 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_2 X_g3_p1__2 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_3 X_g3_p1__3 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_3 nm cn X_g3_p1__3 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN nm cn X_g3_p1 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1 X_g3_p1 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA1 XI7_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPOEN nm c XI7_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2_2 XI1_p1__2 c VDD VNW P18_DNW L=1.8e-07 W=7e-07
mXI1_MXPA1_2 ECK nm XI1_p1__2 VNW P18_DNW L=1.8e-07 W=7e-07
mXI1_MXPA1_3 ECK nm XI1_p1__3 VNW P18_DNW L=1.8e-07 W=7e-07
mXI1_MXPA2_3 XI1_p1__3 c VDD VNW P18_DNW L=1.8e-07 W=7e-07
mXI1_MXPA2 XI1_p1 c VDD VNW P18_DNW L=1.8e-07 W=7e-07
mXI1_MXPA1 ECK nm XI1_p1 VNW P18_DNW L=1.8e-07 W=7e-07
.ends


.SUBCKT TLATNTSCA_X8_A7TR ECK VDD VNW VPW VSS CK E SE
mX_g6_MXNA1 c CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g6_MXNA1_2 c CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g5_MXNA1 cn c VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g8_MXNA1 nmsetin E VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g8_MXNA2 nmsetin SE VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g7_MXNA1 setin nmsetin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1_2 X_g3_n1__2 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_2 nm c X_g3_n1__2 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_3 nm c X_g3_n1__3 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_3 X_g3_n1__3 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1_4 X_g3_n1__4 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE_4 nm c X_g3_n1__4 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNOE nm c X_g3_n1 VPW N18_DNW L=1.8e-07 W=5e-07
mX_g3_MXNA1 X_g3_n1 setin VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 XI7_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNOE nm cn XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA2 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA2_2 ECK c VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1_2 ECK nm VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mX_g6_MXPA1 c CK VDD VNW P18_DNW L=1.8e-07 W=1.31e-06
mX_g6_MXPA1_2 c CK VDD VNW P18_DNW L=1.8e-07 W=1.31e-06
mX_g5_MXPA1 cn c VDD VNW P18_DNW L=1.8e-07 W=7.5e-07
mX_g8_MXPA1 nmsetin E X_g8_p1 VNW P18_DNW L=1.8e-07 W=7e-07
mX_g8_MXPA2 X_g8_p1 SE VDD VNW P18_DNW L=1.8e-07 W=7e-07
mX_g7_MXPA1 setin nmsetin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_2 X_g3_p1__2 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_2 nm cn X_g3_p1__2 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_3 nm cn X_g3_p1__3 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_3 X_g3_p1__3 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1_4 X_g3_p1__4 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN_4 nm cn X_g3_p1__4 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPOEN nm cn X_g3_p1 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g3_MXPA1 X_g3_p1 setin VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA1 XI7_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPOEN nm c XI7_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2_2 XI1_p1__2 c VDD VNW P18_DNW L=1.8e-07 W=6e-07
mXI1_MXPA1_2 ECK nm XI1_p1__2 VNW P18_DNW L=1.8e-07 W=6e-07
mXI1_MXPA1_3 ECK nm XI1_p1__3 VNW P18_DNW L=1.8e-07 W=6e-07
mXI1_MXPA2_3 XI1_p1__3 c VDD VNW P18_DNW L=1.8e-07 W=6e-07
mXI1_MXPA2_4 XI1_p1__4 c VDD VNW P18_DNW L=1.8e-07 W=6e-07
mXI1_MXPA1_4 ECK nm XI1_p1__4 VNW P18_DNW L=1.8e-07 W=6e-07
mXI1_MXPA1 ECK nm XI1_p1 VNW P18_DNW L=1.8e-07 W=6e-07
mXI1_MXPA2 XI1_p1 c VDD VNW P18_DNW L=1.8e-07 W=6e-07
.ends


.SUBCKT TLATN_X1_A7TR Q QN VDD VNW VPW VSS D GN
mX_g5_MXNA1 cn GN VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
mX_g4_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 XI1_n1 D VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI1_MXNOE nm cn XI1_n1 VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI0_MXNOE nm c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXNA1 XI0_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI21_MXNA1 Q nm VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g1_MXNA1 QN m VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g5_MXPA1 cn GN VDD VNW P18_DNW L=1.8e-07 W=5.8e-07
mX_g4_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 XI1_p1 D VDD VNW P18_DNW L=1.8e-07 W=9.7e-07
mXI1_MXPOEN nm c XI1_p1 VNW P18_DNW L=1.8e-07 W=9.7e-07
mXI0_MXPOEN nm cn XI0_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXPA1 XI0_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI21_MXPA1 Q nm VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g1_MXPA1 QN m VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
.ends


.SUBCKT TLATN_X2_A7TR Q QN VDD VNW VPW VSS D GN
mX_g5_MXNA1 cn GN VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
mX_g4_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 XI1_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.7e-07
mXI1_MXNOE nm cn XI1_n1 VPW N18_DNW L=1.8e-07 W=8.7e-07
mXI0_MXNOE nm c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXNA1 XI0_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mXI21_MXNA1 Q nm VSS VPW N18_DNW L=1.8e-07 W=8e-07
mX_g1_MXNA1 QN m VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g5_MXPA1 cn GN VDD VNW P18_DNW L=1.8e-07 W=5.8e-07
mX_g4_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 XI1_p1 D VDD VNW P18_DNW L=1.8e-07 W=1.13e-06
mXI1_MXPOEN nm c XI1_p1 VNW P18_DNW L=1.8e-07 W=1.13e-06
mXI0_MXPOEN nm cn XI0_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXPA1 XI0_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI21_MXPA1 Q nm VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1 QN m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT TLATN_X4_A7TR Q QN VDD VNW VPW VSS D GN
mX_g5_MXNA1 cn GN VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g4_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI1_MXNA1 XI1_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI1_MXNA1_2 XI1_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI1_MXNOE nm cn XI1_n1 VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI1_MXNOE_2 nm cn XI1_n1 VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI0_MXNOE nm c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXNA1 XI0_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI21_MXNA1 Q nm VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI21_MXNA1_2 Q nm VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 QN m VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 QN m VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g5_MXPA1 cn GN VDD VNW P18_DNW L=1.8e-07 W=9.3e-07
mX_g4_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=6.7e-07
mXI1_MXPA1 XI1_p1 D VDD VNW P18_DNW L=1.8e-07 W=1.13e-06
mXI1_MXPA1_2 XI1_p1 D VDD VNW P18_DNW L=1.8e-07 W=1.13e-06
mXI1_MXPOEN nm c XI1_p1 VNW P18_DNW L=1.8e-07 W=1.13e-06
mXI1_MXPOEN_2 nm c XI1_p1 VNW P18_DNW L=1.8e-07 W=1.13e-06
mXI0_MXPOEN nm cn XI0_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI0_MXPA1 XI0_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=8.1e-07
mXI21_MXPA1 Q nm VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI21_MXPA1_2 Q nm VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1 QN m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 QN m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT TLATSR_X1_A7TR Q QN VDD VNW VPW VSS D G RN SN
mX_g3_MXNA1 nms SN VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
MX_t6 nm nms VSS VPW N18_DNW L=1.8e-07 W=3.2e-07
MXN1 net84 D VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN0 net80 RN net84 VPW N18_DNW L=1.8e-07 W=5.1e-07
MX_t13 nm c net80 VPW N18_DNW L=1.8e-07 W=5.1e-07
MX_t2 nm cn net100 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN2 net100 RN net105 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN3 VSS m net105 VPW N18_DNW L=1.8e-07 W=4.5e-07
mX_g5_MXNA1 cn G VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
mX_g4_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g0_MXNA1 Q nm VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g1_MXNA1 QN m VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g3_MXPA1 nms SN VDD VNW P18_DNW L=1.8e-07 W=5.2e-07
MXP1 nm cn net47 VNW P18_DNW L=1.8e-07 W=7.4e-07
MXP0 net47 nms net55 VNW P18_DNW L=1.8e-07 W=7.4e-07
MX_t9 net55 D VDD VNW P18_DNW L=1.8e-07 W=7.4e-07
MX_t14 net63 RN VDD VNW P18_DNW L=1.8e-07 W=6.4e-07
MXP2 nm nms net63 VNW P18_DNW L=1.8e-07 W=6.4e-07
MXP4 nm c net71 VNW P18_DNW L=1.8e-07 W=5.1e-07
MXP3 net71 nms net67 VNW P18_DNW L=1.8e-07 W=5.1e-07
MX_t5 VDD m net67 VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g5_MXPA1 cn G VDD VNW P18_DNW L=1.8e-07 W=5.8e-07
mX_g4_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g0_MXPA1 Q nm VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g1_MXPA1 QN m VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT TLATSR_X2_A7TR Q QN VDD VNW VPW VSS D G RN SN
mX_g3_MXNA1 nms SN VSS VPW N18_DNW L=1.8e-07 W=4.7e-07
MX_t6 nm nms VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
MXN1 net84 D VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
MXN0 net80 RN net84 VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t13 nm c net80 VPW N18_DNW L=1.8e-07 W=6.5e-07
MX_t2 nm cn net100 VPW N18_DNW L=1.8e-07 W=3.8e-07
MXN2 net100 RN net105 VPW N18_DNW L=1.8e-07 W=3.8e-07
MXN3 VSS m net105 VPW N18_DNW L=1.8e-07 W=3.8e-07
mX_g5_MXNA1 cn G VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
mX_g4_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g0_MXNA1 Q nm VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 QN m VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXPA1 nms SN VDD VNW P18_DNW L=1.8e-07 W=7.1e-07
MXP1 nm cn net47 VNW P18_DNW L=1.8e-07 W=1.11e-06
MXP0 net47 nms net55 VNW P18_DNW L=1.8e-07 W=1.11e-06
MX_t9 net55 D VDD VNW P18_DNW L=1.8e-07 W=1.11e-06
MX_t14 net63 RN VDD VNW P18_DNW L=1.8e-07 W=9.5e-07
MXP2 nm nms net63 VNW P18_DNW L=1.8e-07 W=9.5e-07
MXP4 nm c net71 VNW P18_DNW L=1.8e-07 W=5.1e-07
MXP3 net71 nms net67 VNW P18_DNW L=1.8e-07 W=5.1e-07
MX_t5 VDD m net67 VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g5_MXPA1 cn G VDD VNW P18_DNW L=1.8e-07 W=5.8e-07
mX_g4_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=5.3e-07
mX_g0_MXPA1 Q nm VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1 QN m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT TLATSR_X4_A7TR Q QN VDD VNW VPW VSS D G RN SN
mX_g3_MXNA1 nms SN VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
MX_t6 nm nms VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN1 net84 D VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
MXN0 net80 RN net84 VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t13 nm c net80 VPW N18_DNW L=1.8e-07 W=6.5e-07
MX_t2 nm cn net100 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN2 net100 RN net105 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN3 VSS m net105 VPW N18_DNW L=1.8e-07 W=4.5e-07
mX_g5_MXNA1 cn G VSS VPW N18_DNW L=1.8e-07 W=4.9e-07
mX_g4_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=6e-07
mX_g0_MXNA1 Q nm VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 Q nm VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 QN m VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 QN m VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXPA1 nms SN VDD VNW P18_DNW L=1.8e-07 W=1.25e-06
MXP1 nm cn net47 VNW P18_DNW L=1.8e-07 W=1.13e-06
MXP0 net47 nms net55 VNW P18_DNW L=1.8e-07 W=1.13e-06
MX_t9 net55 D VDD VNW P18_DNW L=1.8e-07 W=1.13e-06
MX_t14 net63 RN VDD VNW P18_DNW L=1.8e-07 W=1.04e-06
MXP2 nm nms net63 VNW P18_DNW L=1.8e-07 W=1.04e-06
MXP4 nm c net71 VNW P18_DNW L=1.8e-07 W=5.1e-07
MXP3 net71 nms net67 VNW P18_DNW L=1.8e-07 W=5.1e-07
MX_t5 VDD m net67 VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g5_MXPA1 cn G VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
mX_g4_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=5.3e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=8.9e-07
mX_g0_MXPA1 Q nm VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Q nm VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1 QN m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 QN m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT TLAT_X1_A7TR Q QN VDD VNW VPW VSS D G
mX_g6_MXNA1 cn G VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mX_g5_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 X_g3_n1 D VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mX_g3_MXNOE nm c X_g3_n1 VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI5_MXNOE nm cn XI5_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI5_MXNA1 XI5_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI25_MXNA1 Q nm VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g1_MXNA1 QN m VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g6_MXPA1 cn G VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mX_g5_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 X_g3_p1 D VDD VNW P18_DNW L=1.8e-07 W=9.7e-07
mX_g3_MXPOEN nm cn X_g3_p1 VNW P18_DNW L=1.8e-07 W=9.7e-07
mXI5_MXPOEN nm c XI5_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI5_MXPA1 XI5_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI25_MXPA1 Q nm VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g1_MXPA1 QN m VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
.ends

.SUBCKT TLAT_X2_A7TR Q QN VDD VNW VPW VSS D G
mX_g6_MXNA1 cn G VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g5_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 X_g3_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.7e-07
mX_g3_MXNOE nm c X_g3_n1 VPW N18_DNW L=1.8e-07 W=8.7e-07
mXI5_MXNOE nm cn XI5_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI5_MXNA1 XI5_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mXI25_MXNA1 Q nm VSS VPW N18_DNW L=1.8e-07 W=8e-07
mX_g1_MXNA1 QN m VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g6_MXPA1 cn G VDD VNW P18_DNW L=1.8e-07 W=5.3e-07
mX_g5_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 X_g3_p1 D VDD VNW P18_DNW L=1.8e-07 W=1.13e-06
mX_g3_MXPOEN nm cn X_g3_p1 VNW P18_DNW L=1.8e-07 W=1.13e-06
