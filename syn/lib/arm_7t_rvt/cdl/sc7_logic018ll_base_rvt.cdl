mXI5_MXPOEN nm c XI5_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI5_MXPA1 XI5_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI25_MXPA1 Q nm VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1 QN m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT TLAT_X4_A7TR Q QN VDD VNW VPW VSS D G
mX_g6_MXNA1 cn G VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
mX_g5_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=3.1e-07
mX_g3_MXNA1 X_g3_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g3_MXNA1_2 X_g3_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g3_MXNOE nm c X_g3_n1 VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g3_MXNOE_2 nm c X_g3_n1 VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI5_MXNOE nm cn XI5_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI5_MXNA1 XI5_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI25_MXNA1 Q nm VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI25_MXNA1_2 Q nm VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 QN m VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 QN m VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g6_MXPA1 cn G VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
mX_g5_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=4.7e-07
mX_g3_MXPA1 X_g3_p1 D VDD VNW P18_DNW L=1.8e-07 W=1.13e-06
mX_g3_MXPA1_2 X_g3_p1 D VDD VNW P18_DNW L=1.8e-07 W=1.13e-06
mX_g3_MXPOEN nm cn X_g3_p1 VNW P18_DNW L=1.8e-07 W=1.13e-06
mX_g3_MXPOEN_2 nm cn X_g3_p1 VNW P18_DNW L=1.8e-07 W=1.13e-06
mXI5_MXPOEN nm c XI5_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI5_MXPA1 XI5_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=8.1e-07
mXI25_MXPA1 Q nm VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI25_MXPA1_2 Q nm VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1 QN m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 QN m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT XNOR2_X1_A7TR Y VDD VNW VPW VSS A B
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI3_MXNA1 bb nb VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI4_MXNOE Y A bb VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI2_MXNOE Y na nb VPW N18_DNW L=1.8e-07 W=3.9e-07
mXI0_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI3_MXPA1 bb nb VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI4_MXPOEN Y na bb VNW P18_DNW L=1.8e-07 W=5.8e-07
mXI2_MXPOEN Y A nb VNW P18_DNW L=1.8e-07 W=5.8e-07
mXI0_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT XNOR2_X2_A7TR Y VDD VNW VPW VSS A B
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNA1 bb nb VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI4_MXNOE Y A bb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI2_MXNOE Y na nb VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI0_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI3_MXPA1 bb nb VDD VNW P18_DNW L=1.8e-07 W=1.29e-06
mXI4_MXPOEN Y na bb VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI2_MXPOEN Y A nb VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
.ends


.SUBCKT XNOR2_X4_A7TR Y VDD VNW VPW VSS A B
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNA1 bb nb VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNA1_2 bb nb VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI4_MXNOE Y A bb VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI4_MXNOE_2 Y A bb VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI2_MXNOE Y na nb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI2_MXNOE_2 Y na nb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI3_MXPA1 bb nb VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI3_MXPA1_2 bb nb VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=9e-07
mXI4_MXPOEN Y na bb VNW P18_DNW L=1.8e-07 W=9.5e-07
mXI4_MXPOEN_2 Y na bb VNW P18_DNW L=1.8e-07 W=9.5e-07
mXI2_MXPOEN Y A nb VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI2_MXPOEN_2 Y A nb VNW P18_DNW L=1.8e-07 W=1.16e-06
.ends


.SUBCKT XNOR2_X8_A7TR Y VDD VNW VPW VSS A B
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNA1 bb nb VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNA1_2 bb nb VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNA1_3 bb nb VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNA1_4 bb nb VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI0_MXNA1_2 na A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI4_MXNOE Y A bb VPW N18_DNW L=1.8e-07 W=7.7e-07
mXI4_MXNOE_2 Y A bb VPW N18_DNW L=1.8e-07 W=7.7e-07
mXI4_MXNOE_3 Y A bb VPW N18_DNW L=1.8e-07 W=7.7e-07
mXI4_MXNOE_4 Y A bb VPW N18_DNW L=1.8e-07 W=7.7e-07
mXI2_MXNOE Y na nb VPW N18_DNW L=1.8e-07 W=7.7e-07
mXI2_MXNOE_2 Y na nb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI2_MXNOE_3 Y na nb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI2_MXNOE_4 Y na nb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI3_MXPA1 bb nb VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI3_MXPA1_2 bb nb VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI3_MXPA1_3 bb nb VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI3_MXPA1_4 bb nb VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=9e-07
mXI0_MXPA1_2 na A VDD VNW P18_DNW L=1.8e-07 W=9e-07
mXI4_MXPOEN Y na bb VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI4_MXPOEN_2 Y na bb VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI4_MXPOEN_3 Y na bb VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI4_MXPOEN_4 Y na bb VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI2_MXPOEN Y A nb VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI2_MXPOEN_2 Y A nb VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI2_MXPOEN_3 Y A nb VNW P18_DNW L=1.8e-07 W=1.21e-06
mXI2_MXPOEN_4 Y A nb VNW P18_DNW L=1.8e-07 W=1.21e-06
.ends


.SUBCKT XNOR2_XL_A7TR Y VDD VNW VPW VSS A B
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNA1 bb nb VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI4_MXNOE Y A bb VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI2_MXNOE Y na nb VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI3_MXPA1 bb nb VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI4_MXPOEN Y na bb VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI2_MXPOEN Y A nb VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT XNOR3_X1_A7TR Y VDD VNW VPW VSS A B C
mXI2_MXNA1 nc A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNOE bnc B nc VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI6_MXNOE bnc nb bc VPW N18_DNW L=1.8e-07 W=7e-07
mXI5_MXNA1 bc nc VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1_2 bc nc VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI7_MXNA1 nbnc bnc VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI52_MXNOE ny C nbnc VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI53_MXNOE ny na bnc VPW N18_DNW L=1.8e-07 W=7e-07
mXI0_MXNA1 na C VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI9_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI2_MXPA1 nc A VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI3_MXPOEN bnc nb nc VNW P18_DNW L=1.8e-07 W=1.06e-06
mXI6_MXPOEN bnc B bc VNW P18_DNW L=1.8e-07 W=1e-06
mXI5_MXPA1 bc nc VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI5_MXPA1_2 bc nc VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI7_MXPA1 nbnc bnc VDD VNW P18_DNW L=1.8e-07 W=6.4e-07
mXI52_MXPOEN ny na nbnc VNW P18_DNW L=1.8e-07 W=6.4e-07
mXI53_MXPOEN ny C bnc VNW P18_DNW L=1.8e-07 W=1.01e-06
mXI0_MXPA1 na C VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI9_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT XNOR3_X2_A7TR Y VDD VNW VPW VSS A B C
mXI2_MXNA1 nc A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI4_MXNOE bnc B nc VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI6_MXNOE bnc nb bc VPW N18_DNW L=1.8e-07 W=7e-07
mXI5_MXNA1 bc nc VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1_2 bc nc VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI7_MXNA1 nbnc bnc VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI8_MXNOE ny C nbnc VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI48_MXNOE ny na bnc VPW N18_DNW L=1.8e-07 W=7e-07
mXI0_MXNA1 na C VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI9_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI2_MXPA1 nc A VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI4_MXPOEN bnc nb nc VNW P18_DNW L=1.8e-07 W=1.06e-06
mXI6_MXPOEN bnc B bc VNW P18_DNW L=1.8e-07 W=1e-06
mXI5_MXPA1 bc nc VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI5_MXPA1_2 bc nc VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI7_MXPA1 nbnc bnc VDD VNW P18_DNW L=1.8e-07 W=9.1e-07
mXI8_MXPOEN ny na nbnc VNW P18_DNW L=1.8e-07 W=1.01e-06
mXI48_MXPOEN ny C bnc VNW P18_DNW L=1.8e-07 W=1.01e-06
mXI0_MXPA1 na C VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI9_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.29e-06
.ends


.SUBCKT XNOR3_X4_A7TR Y VDD VNW VPW VSS A B C
mXI2_MXNA1 nc A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNOE bnc B nc VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI6_MXNOE bnc nb bc VPW N18_DNW L=1.8e-07 W=7e-07
mXI5_MXNA1 bc nc VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1_2 bc nc VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI7_MXNA1 nbnc bnc VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI7_MXNA1_2 nbnc bnc VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI8_MXNOE ny C nbnc VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI4_MXNOE ny na bnc VPW N18_DNW L=1.8e-07 W=7e-07
mXI0_MXNA1 na C VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI9_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI9_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI2_MXPA1 nc A VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI3_MXPOEN bnc nb nc VNW P18_DNW L=1.8e-07 W=1.06e-06
mXI6_MXPOEN bnc B bc VNW P18_DNW L=1.8e-07 W=1e-06
mXI5_MXPA1 bc nc VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI5_MXPA1_2 bc nc VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI7_MXPA1 nbnc bnc VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI7_MXPA1_2 nbnc bnc VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI8_MXPOEN ny na nbnc VNW P18_DNW L=1.8e-07 W=1.01e-06
mXI4_MXPOEN ny C bnc VNW P18_DNW L=1.8e-07 W=1.01e-06
mXI0_MXPA1 na C VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI9_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI9_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT XNOR3_X8_A7TR Y VDD VNW VPW VSS A B C
mXI2_MXNA1 nc A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNOE bnc B nc VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI6_MXNOE bnc nb bc VPW N18_DNW L=1.8e-07 W=7e-07
mXI5_MXNA1 bc nc VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1_2 bc nc VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI7_MXNA1 nbnc bnc VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI7_MXNA1_2 nbnc bnc VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI7_MXNA1_3 nbnc bnc VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI7_MXNA1_4 nbnc bnc VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI8_MXNOE ny C nbnc VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI4_MXNOE ny na bnc VPW N18_DNW L=1.8e-07 W=7.2e-07
mXI0_MXNA1 na C VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI9_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI9_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI9_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI9_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI2_MXPA1 nc A VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI3_MXPOEN bnc nb nc VNW P18_DNW L=1.8e-07 W=1.06e-06
mXI6_MXPOEN bnc B bc VNW P18_DNW L=1.8e-07 W=1e-06
mXI5_MXPA1 bc nc VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI5_MXPA1_2 bc nc VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI7_MXPA1 nbnc bnc VDD VNW P18_DNW L=1.8e-07 W=1.07e-06
mXI7_MXPA1_2 nbnc bnc VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI7_MXPA1_3 nbnc bnc VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI7_MXPA1_4 nbnc bnc VDD VNW P18_DNW L=1.8e-07 W=1.06e-06
mXI8_MXPOEN ny na nbnc VNW P18_DNW L=1.8e-07 W=1.01e-06
mXI4_MXPOEN ny C bnc VNW P18_DNW L=1.8e-07 W=1.01e-06
mXI0_MXPA1 na C VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI9_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI9_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI9_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI9_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT XNOR3_XL_A7TR Y VDD VNW VPW VSS A B C
mXI2_MXNA1 nc A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI3_MXNOE bnc B nc VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI6_MXNOE bnc nb bc VPW N18_DNW L=1.8e-07 W=5e-07
mXI5_MXNA1 bc nc VSS VPW N18_DNW L=1.8e-07 W=5e-07
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 nbnc bnc VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI8_MXNOE ny C nbnc VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNOE ny na bnc VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI0_MXNA1 na C VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI9_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI2_MXPA1 nc A VDD VNW P18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXPOEN bnc nb nc VNW P18_DNW L=1.8e-07 W=8.8e-07
mXI6_MXPOEN bnc B bc VNW P18_DNW L=1.8e-07 W=7.5e-07
mXI5_MXPA1 bc nc VDD VNW P18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA1 nbnc bnc VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI8_MXPOEN ny na nbnc VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXPOEN ny C bnc VNW P18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 na C VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI9_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT XOR2_X1_A7TR Y VDD VNW VPW VSS A B
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI3_MXNA1 bb nb VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI4_MXNOE Y na bb VPW N18_DNW L=1.8e-07 W=3.9e-07
mXI2_MXNOE Y A nb VPW N18_DNW L=1.8e-07 W=3.9e-07
mXI0_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI3_MXPA1 bb nb VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI4_MXPOEN Y A bb VNW P18_DNW L=1.8e-07 W=5.8e-07
mXI2_MXPOEN Y na nb VNW P18_DNW L=1.8e-07 W=5.8e-07
mXI0_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT XOR2_X2_A7TR Y VDD VNW VPW VSS A B
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNA1 bb nb VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI4_MXNOE Y na bb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI2_MXNOE Y A nb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI0_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI3_MXPA1 bb nb VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI4_MXPOEN Y A bb VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI2_MXPOEN Y na nb VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI0_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
.ends


.SUBCKT XOR2_X3_A7TR Y VDD VNW VPW VSS A B
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI1_MXNA1_2 nb B VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI3_MXNA1 bb nb VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI3_MXNA1_2 bb nb VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI2_MXNOE Y A nb VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI2_MXNOE_2 Y A nb VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI4_MXNOE Y na bb VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI4_MXNOE_2 Y na bb VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI1_MXPA1_2 nb B VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI3_MXPA1 bb nb VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI3_MXPA1_2 bb nb VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI0_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI2_MXPOEN Y na nb VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI2_MXPOEN_2 Y na nb VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI4_MXPOEN Y A bb VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI4_MXPOEN_2 Y A bb VNW P18_DNW L=1.8e-07 W=8.7e-07
.ends


.SUBCKT XOR2_X4_A7TR Y VDD VNW VPW VSS A B
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNA1 bb nb VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNA1_2 bb nb VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI2_MXNOE Y A nb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI2_MXNOE_2 Y A nb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI4_MXNOE Y na bb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI4_MXNOE_2 Y na bb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI3_MXPA1 bb nb VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI3_MXPA1_2 bb nb VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=9e-07
mXI2_MXPOEN Y na nb VNW P18_DNW L=1.8e-07 W=9.3e-07
mXI2_MXPOEN_2 Y na nb VNW P18_DNW L=1.8e-07 W=9.3e-07
mXI4_MXPOEN Y A bb VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI4_MXPOEN_2 Y A bb VNW P18_DNW L=1.8e-07 W=1.16e-06
.ends


.SUBCKT XOR2_X8_A7TR Y VDD VNW VPW VSS A B
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNA1 bb nb VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNA1_2 bb nb VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNA1_3 bb nb VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNA1_4 bb nb VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI0_MXNA1_2 na A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI2_MXNOE Y A nb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI2_MXNOE_2 Y A nb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI2_MXNOE_3 Y A nb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI2_MXNOE_4 Y A nb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI4_MXNOE Y na bb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI4_MXNOE_2 Y na bb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI4_MXNOE_3 Y na bb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI4_MXNOE_4 Y na bb VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI3_MXPA1 bb nb VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI3_MXPA1_2 bb nb VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI3_MXPA1_3 bb nb VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI3_MXPA1_4 bb nb VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=9e-07
mXI0_MXPA1_2 na A VDD VNW P18_DNW L=1.8e-07 W=9e-07
mXI2_MXPOEN Y na nb VNW P18_DNW L=1.8e-07 W=9.3e-07
mXI2_MXPOEN_2 Y na nb VNW P18_DNW L=1.8e-07 W=9.3e-07
mXI2_MXPOEN_3 Y na nb VNW P18_DNW L=1.8e-07 W=9.3e-07
mXI2_MXPOEN_4 Y na nb VNW P18_DNW L=1.8e-07 W=9.3e-07
mXI4_MXPOEN Y A bb VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI4_MXPOEN_2 Y A bb VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI4_MXPOEN_3 Y A bb VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI4_MXPOEN_4 Y A bb VNW P18_DNW L=1.8e-07 W=1.16e-06
.ends


.SUBCKT XOR2_XL_A7TR Y VDD VNW VPW VSS A B
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNA1 bb nb VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNOE Y na bb VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI2_MXNOE Y A nb VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI3_MXPA1 bb nb VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI4_MXPOEN Y A bb VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI2_MXPOEN Y na nb VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT XOR3_X1_A7TR Y VDD VNW VPW VSS A B C
mXI2_MXNA1 nc A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNOE bnc B nc VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI6_MXNOE bnc nb bc VPW N18_DNW L=1.8e-07 W=7e-07
mXI5_MXNA1 bc nc VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1_2 bc nc VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI7_MXNA1 nbnc bnc VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI8_MXNOE ny na nbnc VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI4_MXNOE ny C bnc VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXNA1 na C VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI9_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI2_MXPA1 nc A VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI3_MXPOEN bnc nb nc VNW P18_DNW L=1.8e-07 W=1.06e-06
mXI6_MXPOEN bnc B bc VNW P18_DNW L=1.8e-07 W=1e-06
mXI5_MXPA1 bc nc VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI5_MXPA1_2 bc nc VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI7_MXPA1 nbnc bnc VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
mXI8_MXPOEN ny C nbnc VNW P18_DNW L=1.8e-07 W=8.6e-07
mXI4_MXPOEN ny na bnc VNW P18_DNW L=1.8e-07 W=9.5e-07
mXI0_MXPA1 na C VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI9_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT XOR3_X2_A7TR Y VDD VNW VPW VSS A B C
mXI2_MXNA1 nc A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNOE bnc B nc VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI6_MXNOE bnc nb bc VPW N18_DNW L=1.8e-07 W=7e-07
mXI5_MXNA1 bc nc VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1_2 bc nc VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI7_MXNA1 nbnc bnc VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI8_MXNOE ny na nbnc VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI4_MXNOE ny C bnc VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXNA1 na C VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI9_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI2_MXPA1 nc A VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI3_MXPOEN bnc nb nc VNW P18_DNW L=1.8e-07 W=1.06e-06
mXI6_MXPOEN bnc B bc VNW P18_DNW L=1.8e-07 W=1e-06
mXI5_MXPA1 bc nc VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI5_MXPA1_2 bc nc VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI7_MXPA1 nbnc bnc VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
mXI8_MXPOEN ny C nbnc VNW P18_DNW L=1.8e-07 W=8.6e-07
mXI4_MXPOEN ny na bnc VNW P18_DNW L=1.8e-07 W=8.3e-07
mXI0_MXPA1 na C VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI9_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.29e-06
.ends


.SUBCKT XOR3_X4_A7TR Y VDD VNW VPW VSS A B C
mXI2_MXNA1 nc A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNOE bnc B nc VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI6_MXNOE bnc nb bc VPW N18_DNW L=1.8e-07 W=7e-07
mXI5_MXNA1 bc nc VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1_2 bc nc VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI7_MXNA1 nbnc bnc VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI7_MXNA1_2 nbnc bnc VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI8_MXNOE ny na nbnc VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI4_MXNOE ny C bnc VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXNA1 na C VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI9_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI9_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI2_MXPA1 nc A VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
mXI3_MXPOEN bnc nb nc VNW P18_DNW L=1.8e-07 W=1.06e-06
mXI6_MXPOEN bnc B bc VNW P18_DNW L=1.8e-07 W=1e-06
mXI5_MXPA1 bc nc VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI5_MXPA1_2 bc nc VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI7_MXPA1 nbnc bnc VDD VNW P18_DNW L=1.8e-07 W=1.03e-06
mXI7_MXPA1_2 nbnc bnc VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI8_MXPOEN ny C nbnc VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI4_MXPOEN ny na bnc VNW P18_DNW L=1.8e-07 W=9.5e-07
mXI0_MXPA1 na C VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI9_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI9_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT XOR3_X8_A7TR Y VDD VNW VPW VSS A B C
mXI2_MXNA1 nc A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXNOE bnc B nc VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI6_MXNOE bnc nb bc VPW N18_DNW L=1.8e-07 W=7e-07
mXI5_MXNA1 bc nc VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1_2 bc nc VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI7_MXNA1 nbnc bnc VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI7_MXNA1_2 nbnc bnc VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI7_MXNA1_3 nbnc bnc VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI7_MXNA1_4 nbnc bnc VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI8_MXNOE ny na nbnc VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI4_MXNOE ny C bnc VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXNA1 na C VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI9_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI9_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI9_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI9_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI2_MXPA1 nc A VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
mXI3_MXPOEN bnc nb nc VNW P18_DNW L=1.8e-07 W=1.06e-06
mXI6_MXPOEN bnc B bc VNW P18_DNW L=1.8e-07 W=1e-06
mXI5_MXPA1 bc nc VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI5_MXPA1_2 bc nc VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI7_MXPA1 nbnc bnc VDD VNW P18_DNW L=1.8e-07 W=1.07e-06
mXI7_MXPA1_2 nbnc bnc VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI7_MXPA1_3 nbnc bnc VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI7_MXPA1_4 nbnc bnc VDD VNW P18_DNW L=1.8e-07 W=1.06e-06
mXI8_MXPOEN ny C nbnc VNW P18_DNW L=1.8e-07 W=1.07e-06
mXI4_MXPOEN ny na bnc VNW P18_DNW L=1.8e-07 W=9.5e-07
mXI0_MXPA1 na C VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI9_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI9_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI9_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI9_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT XOR3_XL_A7TR Y VDD VNW VPW VSS A B C
mXI2_MXNA1 nc A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI3_MXNOE bnc B nc VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI6_MXNOE bnc nb bc VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI5_MXNA1 bc nc VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 nbnc bnc VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI8_MXNOE ny na nbnc VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNOE ny C bnc VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI0_MXNA1 na C VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI9_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI2_MXPA1 nc A VDD VNW P18_DNW L=1.8e-07 W=8.8e-07
mXI3_MXPOEN bnc nb nc VNW P18_DNW L=1.8e-07 W=8.8e-07
mXI6_MXPOEN bnc B bc VNW P18_DNW L=1.8e-07 W=7.5e-07
mXI5_MXPA1 bc nc VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
mXI1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA1 nbnc bnc VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI8_MXPOEN ny C nbnc VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXPOEN ny na bnc VNW P18_DNW L=1.8e-07 W=8.2e-07
mXI0_MXPA1 na C VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI9_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends
