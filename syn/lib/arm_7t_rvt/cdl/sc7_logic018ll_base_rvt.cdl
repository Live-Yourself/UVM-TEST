* ---------------------------------------------------------------------------- 
* 
*     library Calibre-based CDL file 
* 
*     Date: Nov 15, 2010 3:17:53 PM IST 
* 
*     CellBuilder version 3.6.0 -- built on Oct 12, 2010 
*     Copyright (c) 2002-2009 ARM, Inc. 
*     The confidential and proprietary information contained in this file 
*     may only be used by a person authorised under and to the extent 
*     permitted by a subsisting licensing agreement from ARM Limited. 
*      
*     (C) COPYRIGHT 2004-2010 ARM Limited. 
*     ALL RIGHTS RESERVED 
*      
*     This entire notice must be reproduced on all copies of this file 
*     and copies of this file may only be made by a person if such person 
*     is permitted to do so under the terms of a subsisting license 
*     agreement from ARM Limited. 
* 
* ----------------------------------------------------------------------------

*.EQUATION
.PARAM 
*.scale meter
.SUBCKT ADDFH_X1_A7TR CO S VDD VNW VPW VSS A B CI
mXI0_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI2_MXNA1 na2 A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI15_MXNA1 ba na2 VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI3_MXNOE xnorab B ba VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI1_MXNOE xnorab nb na VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI4_MXNOE xorab B na VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI5_MXNOE xorab nb ba VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI6_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
mXI11_MXNOE con xnorab nb VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI12_MXNOE con xorab cin VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI9_MXNOE sumn xnorab cin VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI10_MXNOE sumn xorab cib VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI8_MXNA1 cib cin VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI7_MXNA1 cin CI VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI14_MXNA1 CO con VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI13_MXNA1 S sumn VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=1e-06
mXI2_MXPA1 na2 A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI15_MXPA1 ba na2 VDD VNW P18_DNW L=1.8e-07 W=1e-06
mXI3_MXPOEN xnorab nb ba VNW P18_DNW L=1.8e-07 W=1e-06
mXI1_MXPOEN xnorab B na VNW P18_DNW L=1.8e-07 W=8.5e-07
mXI4_MXPOEN xorab nb na VNW P18_DNW L=1.8e-07 W=1e-06
mXI5_MXPOEN xorab B ba VNW P18_DNW L=1.8e-07 W=8.6e-07
mXI6_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=6.3e-07
mXI6_MXPA1_2 nb B VDD VNW P18_DNW L=1.8e-07 W=6.9e-07
mXI11_MXPOEN con xorab nb VNW P18_DNW L=1.8e-07 W=6e-07
mXI12_MXPOEN con xnorab cin VNW P18_DNW L=1.8e-07 W=6e-07
mXI9_MXPOEN sumn xorab cin VNW P18_DNW L=1.8e-07 W=6e-07
mXI10_MXPOEN sumn xnorab cib VNW P18_DNW L=1.8e-07 W=6e-07
mXI8_MXPA1 cib cin VDD VNW P18_DNW L=1.8e-07 W=6.4e-07
mXI7_MXPA1 cin CI VDD VNW P18_DNW L=1.8e-07 W=8.9e-07
mXI14_MXPA1 CO con VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI13_MXPA1 S sumn VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT ADDFH_X2_A7TR CO S VDD VNW VPW VSS A B CI
mXI0_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI0_MXNA1_2 na A VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI2_MXNA1 na2 A VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI15_MXNA1 ba na2 VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI15_MXNA1_2 ba na2 VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI3_MXNOE xnorab B ba VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI3_MXNOE_2 xnorab B ba VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI1_MXNOE xnorab nb na VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI1_MXNOE_2 xnorab nb na VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI4_MXNOE xorab B na VPW N18_DNW L=1.8e-07 W=5.5e-07
mXI4_MXNOE_2 xorab B na VPW N18_DNW L=1.8e-07 W=4e-07
mXI5_MXNOE xorab nb ba VPW N18_DNW L=1.8e-07 W=9.7e-07
mXI6_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=1.4e-06
mXI11_MXNOE con xnorab nb VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI12_MXNOE con xorab cin VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI9_MXNOE sumn xnorab cin VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI9_MXNOE_2 sumn xnorab cin VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI10_MXNOE sumn xorab cib VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI8_MXNA1 cib cin VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI7_MXNA1 cin CI VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI14_MXNA1 CO con VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI13_MXNA1 S sumn VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=8e-07
mXI0_MXPA1_2 na A VDD VNW P18_DNW L=1.8e-07 W=8e-07
mXI2_MXPA1 na2 A VDD VNW P18_DNW L=1.8e-07 W=6.1e-07
mXI15_MXPA1 ba na2 VDD VNW P18_DNW L=1.8e-07 W=8e-07
mXI15_MXPA1_2 ba na2 VDD VNW P18_DNW L=1.8e-07 W=8e-07
mXI3_MXPOEN xnorab nb ba VNW P18_DNW L=1.8e-07 W=8e-07
mXI3_MXPOEN_2 xnorab nb ba VNW P18_DNW L=1.8e-07 W=8e-07
mXI1_MXPOEN xnorab B na VNW P18_DNW L=1.8e-07 W=8e-07
mXI1_MXPOEN_2 xnorab B na VNW P18_DNW L=1.8e-07 W=8e-07
mXI4_MXPOEN xorab nb na VNW P18_DNW L=1.8e-07 W=8e-07
mXI4_MXPOEN_2 xorab nb na VNW P18_DNW L=1.8e-07 W=8e-07
mXI5_MXPOEN xorab B ba VNW P18_DNW L=1.8e-07 W=1.59e-06
mXI6_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=7.4e-07
mXI6_MXPA1_2 nb B VDD VNW P18_DNW L=1.8e-07 W=7.4e-07
mXI6_MXPA1_3 nb B VDD VNW P18_DNW L=1.8e-07 W=7.4e-07
mXI11_MXPOEN con xorab nb VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI11_MXPOEN_2 con xorab nb VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI12_MXPOEN con xnorab cin VNW P18_DNW L=1.8e-07 W=9.5e-07
mXI9_MXPOEN sumn xorab cin VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI10_MXPOEN sumn xnorab cib VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI8_MXPA1 cib cin VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI7_MXPA1 cin CI VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI14_MXPA1 CO con VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI13_MXPA1 S sumn VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends

.SUBCKT ADDFH_X4_A7TR CO S VDD VNW VPW VSS A B CI
mXI0_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1_2 na A VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI0_MXNA1_3 na A VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI2_MXNA1 na2 A VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI15_MXNA1 ba na2 VSS VPW N18_DNW L=1.8e-07 W=1.06e-06
mXI15_MXNA1_2 ba na2 VSS VPW N18_DNW L=1.8e-07 W=1.06e-06
mXI3_MXNOE xnorab B ba VPW N18_DNW L=1.8e-07 W=1e-06
mXI3_MXNOE_2 xnorab B ba VPW N18_DNW L=1.8e-07 W=1e-06
mXI1_MXNOE xnorab nb na VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI1_MXNOE_2 xnorab nb na VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI4_MXNOE xorab B na VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI4_MXNOE_2 xorab B na VPW N18_DNW L=1.8e-07 W=4e-07
mXI4_MXNOE_3 xorab B na VPW N18_DNW L=1.8e-07 W=4.6e-07
mXI5_MXNOE xorab nb ba VPW N18_DNW L=1.8e-07 W=9.7e-07
mXI6_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=1.4e-06
mXI6_MXNA1_2 nb B VSS VPW N18_DNW L=1.8e-07 W=1.4e-06
mXI11_MXNOE con xnorab nb VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI12_MXNOE con xorab cin VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI9_MXNOE sumn xnorab cin VPW N18_DNW L=1.8e-07 W=3.9e-07
mXI9_MXNOE_2 sumn xnorab cin VPW N18_DNW L=1.8e-07 W=3.9e-07
mXI10_MXNOE sumn xorab cib VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI8_MXNA1 cib cin VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI8_MXNA1_2 cib cin VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI7_MXNA1 cin CI VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI7_MXNA1_2 cin CI VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI13_MXNA1 S sumn VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI13_MXNA1_2 S sumn VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI14_MXNA1 CO con VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI14_MXNA1_2 CO con VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 na A VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI0_MXPA1_3 na A VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI2_MXPA1 na2 A VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
mXI15_MXPA1 ba na2 VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI15_MXPA1_2 ba na2 VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI15_MXPA1_3 ba na2 VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mXI3_MXPOEN xnorab nb ba VNW P18_DNW L=1.8e-07 W=8.6e-07
mXI3_MXPOEN_2 xnorab nb ba VNW P18_DNW L=1.8e-07 W=8.6e-07
mXI1_MXPOEN xnorab B na VNW P18_DNW L=1.8e-07 W=8.4e-07
mXI1_MXPOEN_2 xnorab B na VNW P18_DNW L=1.8e-07 W=8.4e-07
mXI4_MXPOEN xorab nb na VNW P18_DNW L=1.8e-07 W=1.21e-06
mXI4_MXPOEN_2 xorab nb na VNW P18_DNW L=1.8e-07 W=1.21e-06
mXI5_MXPOEN xorab B ba VNW P18_DNW L=1.8e-07 W=1.72e-06
mXI6_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=7.4e-07
mXI6_MXPA1_2 nb B VDD VNW P18_DNW L=1.8e-07 W=7.4e-07
mXI6_MXPA1_3 nb B VDD VNW P18_DNW L=1.8e-07 W=7.4e-07
mXI6_MXPA1_4 nb B VDD VNW P18_DNW L=1.8e-07 W=7.4e-07
mXI6_MXPA1_5 nb B VDD VNW P18_DNW L=1.8e-07 W=7.4e-07
mXI6_MXPA1_6 nb B VDD VNW P18_DNW L=1.8e-07 W=7.4e-07
mXI11_MXPOEN con xorab nb VNW P18_DNW L=1.8e-07 W=8e-07
mXI11_MXPOEN_2 con xorab nb VNW P18_DNW L=1.8e-07 W=8e-07
mXI12_MXPOEN con xnorab cin VNW P18_DNW L=1.8e-07 W=9.5e-07
mXI9_MXPOEN sumn xorab cin VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI10_MXPOEN sumn xnorab cib VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI8_MXPA1 cib cin VDD VNW P18_DNW L=1.8e-07 W=1.03e-06
mXI8_MXPA1_2 cib cin VDD VNW P18_DNW L=1.8e-07 W=1.03e-06
mXI7_MXPA1 cin CI VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI7_MXPA1_2 cin CI VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI13_MXPA1 S sumn VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI13_MXPA1_2 S sumn VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI14_MXPA1 CO con VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI14_MXPA1_2 CO con VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT ADDFH_X8_A7TR CO S VDD VNW VPW VSS A B CI
mXI0_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1_2 na A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 na A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 na A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_5 na A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI2_MXNA1 na2 A VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI2_MXNA1_2 na2 A VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI15_MXNA1 ba na2 VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
mXI15_MXNA1_2 ba na2 VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
mXI15_MXNA1_3 ba na2 VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
mXI15_MXNA1_4 ba na2 VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI15_MXNA1_5 ba na2 VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
mXI3_MXNOE xnorab B ba VPW N18_DNW L=1.8e-07 W=1e-06
mXI3_MXNOE_2 xnorab B ba VPW N18_DNW L=1.8e-07 W=1e-06
mXI1_MXNOE xnorab nb na VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI1_MXNOE_2 xnorab nb na VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI4_MXNOE xorab B na VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI4_MXNOE_2 xorab B na VPW N18_DNW L=1.8e-07 W=4e-07
mXI4_MXNOE_3 xorab B na VPW N18_DNW L=1.8e-07 W=4.6e-07
mXI5_MXNOE xorab nb ba VPW N18_DNW L=1.8e-07 W=9.7e-07
mXI6_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=1.4e-06
mXI6_MXNA1_2 nb B VSS VPW N18_DNW L=1.8e-07 W=1.4e-06
mXI11_MXNOE con xnorab nb VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI12_MXNOE con xorab cin VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI9_MXNOE sumn xnorab cin VPW N18_DNW L=1.8e-07 W=3.9e-07
mXI9_MXNOE_2 sumn xnorab cin VPW N18_DNW L=1.8e-07 W=3.9e-07
mXI10_MXNOE sumn xorab cib VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI8_MXNA1 cib cin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI8_MXNA1_2 cib cin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI8_MXNA1_3 cib cin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI7_MXNA1 cin CI VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI7_MXNA1_2 cin CI VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI7_MXNA1_3 cin CI VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI7_MXNA1_4 cin CI VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI13_MXNA1 S sumn VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI13_MXNA1_2 S sumn VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI13_MXNA1_3 S sumn VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI13_MXNA1_4 S sumn VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI14_MXNA1 CO con VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI14_MXNA1_2 CO con VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI14_MXNA1_3 CO con VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI14_MXNA1_4 CO con VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI0_MXPA1_2 na A VDD VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI0_MXPA1_3 na A VDD VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI0_MXPA1_4 na A VDD VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI0_MXPA1_5 na A VDD VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI2_MXPA1 na2 A VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
mXI2_MXPA1_2 na2 A VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
mXI15_MXPA1 ba na2 VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI15_MXPA1_2 ba na2 VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI15_MXPA1_3 ba na2 VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI15_MXPA1_4 ba na2 VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI15_MXPA1_5 ba na2 VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mXI3_MXPOEN xnorab nb ba VNW P18_DNW L=1.8e-07 W=8.6e-07
mXI3_MXPOEN_2 xnorab nb ba VNW P18_DNW L=1.8e-07 W=8.6e-07
mXI1_MXPOEN xnorab B na VNW P18_DNW L=1.8e-07 W=8.4e-07
mXI1_MXPOEN_2 xnorab B na VNW P18_DNW L=1.8e-07 W=8.4e-07
mXI4_MXPOEN xorab nb na VNW P18_DNW L=1.8e-07 W=1.21e-06
mXI4_MXPOEN_2 xorab nb na VNW P18_DNW L=1.8e-07 W=1.21e-06
mXI5_MXPOEN xorab B ba VNW P18_DNW L=1.8e-07 W=1.35e-06
mXI6_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=7.4e-07
mXI6_MXPA1_2 nb B VDD VNW P18_DNW L=1.8e-07 W=7.4e-07
mXI6_MXPA1_3 nb B VDD VNW P18_DNW L=1.8e-07 W=7.4e-07
mXI6_MXPA1_4 nb B VDD VNW P18_DNW L=1.8e-07 W=7.4e-07
mXI6_MXPA1_5 nb B VDD VNW P18_DNW L=1.8e-07 W=7.4e-07
mXI6_MXPA1_6 nb B VDD VNW P18_DNW L=1.8e-07 W=7.4e-07
mXI11_MXPOEN con xorab nb VNW P18_DNW L=1.8e-07 W=8e-07
mXI11_MXPOEN_2 con xorab nb VNW P18_DNW L=1.8e-07 W=8e-07
mXI12_MXPOEN con xnorab cin VNW P18_DNW L=1.8e-07 W=9.5e-07
mXI9_MXPOEN sumn xorab cin VNW P18_DNW L=1.8e-07 W=1.08e-06
mXI10_MXPOEN sumn xnorab cib VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI8_MXPA1 cib cin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI8_MXPA1_2 cib cin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI8_MXPA1_3 cib cin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI7_MXPA1 cin CI VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI7_MXPA1_2 cin CI VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI7_MXPA1_3 cin CI VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI7_MXPA1_4 cin CI VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI13_MXPA1 S sumn VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI13_MXPA1_2 S sumn VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI13_MXPA1_3 S sumn VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI13_MXPA1_4 S sumn VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI14_MXPA1 CO con VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI14_MXPA1_2 CO con VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI14_MXPA1_3 CO con VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI14_MXPA1_4 CO con VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends

.SUBCKT ADDFH_XL_A7TR CO S VDD VNW VPW VSS A B CI
mXI0_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI2_MXNA1 na2 A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI15_MXNA1 ba na2 VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI3_MXNOE xnorab B ba VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI1_MXNOE xnorab nb na VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI4_MXNOE xorab B na VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI25_MXNOE xorab nb ba VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI6_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI23_MXNOE con xnorab nb VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI24_MXNOE con xorab cin VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI9_MXNOE sumn xnorab cin VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI22_MXNOE sumn xorab cib VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI8_MXNA1 cib cin VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNA1 cin CI VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI14_MXNA1 CO con VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNA1 S sumn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI2_MXPA1 na2 A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI15_MXPA1 ba na2 VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI3_MXPOEN xnorab nb ba VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI1_MXPOEN xnorab B na VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI4_MXPOEN xorab nb na VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI25_MXPOEN xorab B ba VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI6_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=8e-07
mXI23_MXPOEN con xorab nb VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI24_MXPOEN con xnorab cin VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI9_MXPOEN sumn xorab cin VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI22_MXPOEN sumn xnorab cib VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI8_MXPA1 cib cin VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPA1 cin CI VDD VNW P18_DNW L=1.8e-07 W=5.5e-07
mXI14_MXPA1 CO con VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI13_MXPA1 S sumn VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT ADDF_X1_A7TR CO S VDD VNW VPW VSS A B CI
mX_g4_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1 bb nb VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
MXN0 xo na bb VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI6_MXNOE na bb xo VPW N18_DNW L=1.8e-07 W=3e-07
mX_g5_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
mXI5_MXNOE na nb xn VPW N18_DNW L=1.8e-07 W=3e-07
MX_t8 xn na nb VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI7_MXNOE nb xn nco VPW N18_DNW L=1.8e-07 W=3e-07
mXI8_MXNOE nci xo nco VPW N18_DNW L=1.8e-07 W=3e-07
mX_g2_MXNA1 nci CI VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI10_MXNOE ns CI xo VPW N18_DNW L=1.8e-07 W=3e-07
mXI9_MXNOE ns nci xn VPW N18_DNW L=1.8e-07 W=3e-07
mX_g1_MXNA1 CO nco VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g0_MXNA1 S ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g4_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1 bb nb VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t9 bb na xn VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI5_MXPOEN na bb xn VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g5_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI6_MXPOEN na nb xo VNW P18_DNW L=1.8e-07 W=4.5e-07
MXP0 nb na xo VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI7_MXPOEN nb xo nco VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI8_MXPOEN nci xn nco VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g2_MXPA1 nci CI VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI10_MXPOEN ns nci xo VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI9_MXPOEN ns CI xn VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g1_MXPA1 CO nco VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g0_MXPA1 S ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT ADDF_X2_A7TR CO S VDD VNW VPW VSS A B CI
mX_g4_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1 bb nb VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
MXN0 xo na bb VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI6_MXNOE na bb xo VPW N18_DNW L=1.8e-07 W=3e-07
mX_g5_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
mXI5_MXNOE na nb xn VPW N18_DNW L=1.8e-07 W=3e-07
MX_t8 xn na nb VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI7_MXNOE nb xn nco VPW N18_DNW L=1.8e-07 W=3e-07
mXI8_MXNOE nci xo nco VPW N18_DNW L=1.8e-07 W=3e-07
mX_g2_MXNA1 nci CI VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI10_MXNOE ns CI xo VPW N18_DNW L=1.8e-07 W=3e-07
mXI9_MXNOE ns nci xn VPW N18_DNW L=1.8e-07 W=3e-07
mX_g1_MXNA1 CO nco VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 S ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g4_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1 bb nb VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t9 bb na xn VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI5_MXPOEN na bb xn VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g5_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI6_MXPOEN na nb xo VNW P18_DNW L=1.8e-07 W=4.5e-07
MXP0 nb na xo VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI7_MXPOEN nb xo nco VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI8_MXPOEN nci xn nco VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g2_MXPA1 nci CI VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI10_MXPOEN ns nci xo VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI9_MXPOEN ns CI xn VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g1_MXPA1 CO nco VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g0_MXPA1 S ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT ADDF_X4_A7TR CO S VDD VNW VPW VSS A B CI
mX_g4_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1 bb nb VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
MXN0 xo na bb VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI6_MXNOE na bb xo VPW N18_DNW L=1.8e-07 W=3e-07
mX_g5_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
mXI5_MXNOE na nb xn VPW N18_DNW L=1.8e-07 W=3e-07
MX_t8 xn na nb VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI7_MXNOE nb xn nco VPW N18_DNW L=1.8e-07 W=3e-07
mXI8_MXNOE nci xo nco VPW N18_DNW L=1.8e-07 W=3e-07
mX_g2_MXNA1 nci CI VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI10_MXNOE ns CI xo VPW N18_DNW L=1.8e-07 W=3e-07
mXI9_MXNOE ns nci xn VPW N18_DNW L=1.8e-07 W=3e-07
mX_g1_MXNA1 CO nco VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 CO nco VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 S ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 S ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g4_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1 bb nb VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t9 bb na xn VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI5_MXPOEN na bb xn VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g5_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI6_MXPOEN na nb xo VNW P18_DNW L=1.8e-07 W=4.5e-07
MXP0 nb na xo VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI7_MXPOEN nb xo nco VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI8_MXPOEN nci xn nco VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g2_MXPA1 nci CI VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI10_MXPOEN ns nci xo VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI9_MXPOEN ns CI xn VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g1_MXPA1 CO nco VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 CO nco VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1 S ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 S ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends

.SUBCKT ADDF_X8_A7TR CO S VDD VNW VPW VSS A B CI
mX_g4_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1 bb nb VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
MXN0 xo na bb VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI6_MXNOE na bb xo VPW N18_DNW L=1.8e-07 W=3e-07
mX_g5_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
mXI5_MXNOE na nb xn VPW N18_DNW L=1.8e-07 W=3e-07
MX_t8 xn na nb VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI7_MXNOE nb xn nco VPW N18_DNW L=1.8e-07 W=3e-07
mXI8_MXNOE nci xo nco VPW N18_DNW L=1.8e-07 W=3e-07
mX_g2_MXNA1 nci CI VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI10_MXNOE ns CI xo VPW N18_DNW L=1.8e-07 W=3e-07
mXI9_MXNOE ns nci xn VPW N18_DNW L=1.8e-07 W=3e-07
mX_g1_MXNA1 CO nco VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 CO nco VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_3 CO nco VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_4 CO nco VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 S ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 S ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_3 S ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_4 S ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g4_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1 bb nb VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t9 bb na xn VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI5_MXPOEN na bb xn VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g5_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI6_MXPOEN na nb xo VNW P18_DNW L=1.8e-07 W=4.5e-07
MXP0 nb na xo VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI7_MXPOEN nb xo nco VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI8_MXPOEN nci xn nco VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g2_MXPA1 nci CI VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI10_MXPOEN ns nci xo VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI9_MXPOEN ns CI xn VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g1_MXPA1 CO nco VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 CO nco VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_3 CO nco VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_4 CO nco VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1 S ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 S ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_3 S ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_4 S ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT ADDF_XL_A7TR CO S VDD VNW VPW VSS A B CI
mX_g4_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1 bb nb VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
MXN0 xo na bb VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI6_MXNOE na bb xo VPW N18_DNW L=1.8e-07 W=3e-07
mX_g5_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
mXI5_MXNOE na nb xn VPW N18_DNW L=1.8e-07 W=3e-07
MX_t8 xn na nb VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI7_MXNOE nb xn nco VPW N18_DNW L=1.8e-07 W=3e-07
mXI8_MXNOE nci xo nco VPW N18_DNW L=1.8e-07 W=3e-07
mX_g2_MXNA1 nci CI VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI10_MXNOE ns CI xo VPW N18_DNW L=1.8e-07 W=3e-07
mXI9_MXNOE ns nci xn VPW N18_DNW L=1.8e-07 W=3e-07
mX_g1_MXNA1 CO nco VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g0_MXNA1 S ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g4_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1 bb nb VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t9 bb na xn VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI5_MXPOEN na bb xn VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g5_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI6_MXPOEN na nb xo VNW P18_DNW L=1.8e-07 W=4.5e-07
MXP0 nb na xo VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI7_MXPOEN nb xo nco VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI8_MXPOEN nci xn nco VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g2_MXPA1 nci CI VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI10_MXPOEN ns nci xo VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI9_MXPOEN ns CI xn VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g1_MXPA1 CO nco VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g0_MXPA1 S ns VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT ADDH_X1_A7TR CO S VDD VNW VPW VSS A B
mX_g3_MXNA1 ba na VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI10_MXNOE S nb ba VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI9_MXNOE S B na VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g4_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g2_MXNA2 X_g2_n1 A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 nco B X_g2_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g0_MXNA1 CO nco VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g3_MXPA1 ba na VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI10_MXPOEN S B ba VNW P18_DNW L=1.8e-07 W=5.8e-07
mXI9_MXPOEN S nb na VNW P18_DNW L=1.8e-07 W=5.8e-07
mX_g4_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g2_MXPA2 nco A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 nco B VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g0_MXPA1 CO nco VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT ADDH_X2_A7TR CO S VDD VNW VPW VSS A B
mX_g1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=3e-07
mX_g3_MXNA1 ba na VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI10_MXNOE S nb ba VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI9_MXNOE S B na VPW N18_DNW L=1.8e-07 W=7.8e-07
mX_g2_MXNA1 nco B X_g2_n1 VPW N18_DNW L=1.8e-07 W=4.5e-07
mX_g2_MXNA2 X_g2_n1 A VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mX_g4_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
mX_g4_MXNA1_2 na A VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
mX_g0_MXNA1 CO nco VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g3_MXPA1 ba na VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI10_MXPOEN S B ba VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI9_MXPOEN S nb na VNW P18_DNW L=1.8e-07 W=1.16e-06
mX_g2_MXPA1 nco B VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g2_MXPA2 nco A VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g4_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g4_MXPA1_2 na A VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g0_MXPA1 CO nco VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT ADDH_X4_A7TR CO S VDD VNW VPW VSS A B
mX_g3_MXNA1 ba na VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1_2 ba na VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI10_MXNOE S nb ba VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI10_MXNOE_2 S nb ba VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI9_MXNOE S B na VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI9_MXNOE_2 S B na VPW N18_DNW L=1.8e-07 W=7.8e-07
mX_g2_MXNA1 nco B X_g2_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA2 X_g2_n1 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g4_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g4_MXNA1_2 na A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g4_MXNA1_3 na A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 CO nco VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 CO nco VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXPA1 ba na VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_2 ba na VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=9e-07
mXI10_MXPOEN S B ba VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI10_MXPOEN_2 S B ba VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI9_MXPOEN S nb na VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI9_MXPOEN_2 S nb na VNW P18_DNW L=1.8e-07 W=1.16e-06
mX_g2_MXPA1 nco B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g2_MXPA2 nco A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g4_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
mX_g4_MXPA1_2 na A VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
mX_g4_MXPA1_3 na A VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
mX_g0_MXPA1 CO nco VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 CO nco VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT ADDH_X8_A7TR CO S VDD VNW VPW VSS A B
mX_g3_MXNA1 ba na VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1_2 ba na VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1_3 ba na VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g3_MXNA1_4 ba na VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=6e-07
mX_g1_MXNA1_2 nb B VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI10_MXNOE S nb ba VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI10_MXNOE_2 S nb ba VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI10_MXNOE_3 S nb ba VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI10_MXNOE_4 S nb ba VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI9_MXNOE S B na VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI9_MXNOE_2 S B na VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI9_MXNOE_3 S B na VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI9_MXNOE_4 S B na VPW N18_DNW L=1.8e-07 W=7.8e-07
mX_g2_MXNA1 nco B X_g2_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1_2 nco B X_g2_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA2 X_g2_n1 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA2_2 X_g2_n1 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g4_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mX_g4_MXNA1_2 na A VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mX_g4_MXNA1_3 na A VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mX_g4_MXNA1_4 na A VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mX_g4_MXNA1_5 na A VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mX_g4_MXNA1_6 na A VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mX_g0_MXNA1 CO nco VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 CO nco VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_3 CO nco VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g0_MXNA1_4 CO nco VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXPA1 ba na VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g3_MXPA1_2 ba na VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_3 ba na VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1_4 ba na VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=9e-07
mX_g1_MXPA1_2 nb B VDD VNW P18_DNW L=1.8e-07 W=9e-07
mXI10_MXPOEN S B ba VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI10_MXPOEN_2 S B ba VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI10_MXPOEN_3 S B ba VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI10_MXPOEN_4 S B ba VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI9_MXPOEN S nb na VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI9_MXPOEN_2 S nb na VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI9_MXPOEN_3 S nb na VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI9_MXPOEN_4 S nb na VNW P18_DNW L=1.8e-07 W=1.16e-06
mX_g2_MXPA1 nco B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g2_MXPA1_2 nco B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g2_MXPA2 nco A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g2_MXPA2_2 nco A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g4_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
mX_g4_MXPA1_2 na A VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
mX_g4_MXPA1_3 na A VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
mX_g4_MXPA1_4 na A VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
mX_g4_MXPA1_5 na A VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
mX_g4_MXPA1_6 na A VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
mX_g0_MXPA1 CO nco VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 CO nco VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_3 CO nco VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_4 CO nco VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AND2_X12_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA1_2 ny A XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 XI0_n1__2 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_3 XI0_n1__3 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 ny A XI0_n1__3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 ny A XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA2_2 ny B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_3 ny A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA2_3 ny B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends

.SUBCKT AND2_X1_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA1 ny A XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT AND2_X2_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA1 ny A XI0_n1 VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AND2_X4_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA1 ny A XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AND2_X6_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2_2 XI0_n1__2 B VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI0_MXNA1_2 ny A XI0_n1__2 VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI0_MXNA1 ny A XI0_n1 VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA2_2 ny B VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AND2_X8_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2_2 XI0_n1__2 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 ny A XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 ny A XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA2_2 ny B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AND3_X12_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA1_2 ny A XI0_n2__2 VPW N18_DNW L=1.8e-07 W=9.7e-07
mXI0_MXNA2_2 XI0_n2__2 B XI0_n1__2 VPW N18_DNW L=1.8e-07 W=9.7e-07
mXI0_MXNA3_2 XI0_n1__2 C VSS VPW N18_DNW L=1.8e-07 W=9.7e-07
mXI0_MXNA3_3 XI0_n1__3 C VSS VPW N18_DNW L=1.8e-07 W=9.7e-07
mXI0_MXNA2_3 XI0_n2__3 B XI0_n1__3 VPW N18_DNW L=1.8e-07 W=9.7e-07
mXI0_MXNA1_3 ny A XI0_n2__3 VPW N18_DNW L=1.8e-07 W=9.7e-07
mXI0_MXNA1 ny A XI0_n2 VPW N18_DNW L=1.8e-07 W=9.7e-07
mXI0_MXNA2 XI0_n2 B XI0_n1 VPW N18_DNW L=1.8e-07 W=9.7e-07
mXI0_MXNA3 XI0_n1 C VSS VPW N18_DNW L=1.8e-07 W=9.7e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA3 ny C VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA3_2 ny C VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA2_2 ny B VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA1_3 ny A VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA2_3 ny B VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA3_3 ny C VDD VNW P18_DNW L=1.8e-07 W=8.9e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT AND3_X1_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA1 ny A XI0_n2 VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI0_MXNA2 XI0_n2 B XI0_n1 VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI0_MXNA3 XI0_n1 C VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA3 ny C VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT AND3_X2_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA1 ny A XI0_n2 VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA2 XI0_n2 B XI0_n1 VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA3 XI0_n1 C VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXPA3 ny C VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AND3_X4_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA1 ny A XI0_n2 VPW N18_DNW L=1.8e-07 W=1e-06
mXI0_MXNA2 XI0_n2 B XI0_n1 VPW N18_DNW L=1.8e-07 W=1e-06
mXI0_MXNA3 XI0_n1 C VSS VPW N18_DNW L=1.8e-07 W=1e-06
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.01e-06
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=1.01e-06
mXI0_MXPA3 ny C VDD VNW P18_DNW L=1.8e-07 W=1.01e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.2e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AND3_X6_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA3_2 XI0_n1__2 C VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mXI0_MXNA2_2 XI0_n2__2 B XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.1e-07
mXI0_MXNA1_2 ny A XI0_n2__2 VPW N18_DNW L=1.8e-07 W=8.1e-07
mXI0_MXNA1 ny A XI0_n2 VPW N18_DNW L=1.8e-07 W=8.1e-07
mXI0_MXNA2 XI0_n2 B XI0_n1 VPW N18_DNW L=1.8e-07 W=8.1e-07
mXI0_MXNA3 XI0_n1 C VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA3 ny C VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA2_2 ny B VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA3_2 ny C VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AND3_X8_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA1_2 ny A XI0_n2__2 VPW N18_DNW L=1.8e-07 W=7.2e-07
mXI0_MXNA2_2 XI0_n2__2 B XI0_n1__2 VPW N18_DNW L=1.8e-07 W=7.2e-07
mXI0_MXNA3_2 XI0_n1__2 C VSS VPW N18_DNW L=1.8e-07 W=7.2e-07
mXI0_MXNA3_3 XI0_n1__3 C VSS VPW N18_DNW L=1.8e-07 W=7.2e-07
mXI0_MXNA2_3 XI0_n2__3 B XI0_n1__3 VPW N18_DNW L=1.8e-07 W=7.2e-07
mXI0_MXNA1_3 ny A XI0_n2__3 VPW N18_DNW L=1.8e-07 W=7.2e-07
mXI0_MXNA1 ny A XI0_n2 VPW N18_DNW L=1.8e-07 W=7.2e-07
mXI0_MXNA2 XI0_n2 B XI0_n1 VPW N18_DNW L=1.8e-07 W=7.2e-07
mXI0_MXNA3 XI0_n1 C VSS VPW N18_DNW L=1.8e-07 W=7.2e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA3 ny C VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA2_2 ny B VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA3_2 ny C VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AND3_XL_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA1 ny A XI0_n2 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 XI0_n2 B XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA3 XI0_n1 C VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA3 ny C VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends

.SUBCKT AND4_X12_A7TR Y VDD VNW VPW VSS A B C D
mXI0_MXNA1 ny A XI0_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 ny A XI0_n3 VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI0_MXNA1_3 ny A XI0_n3 VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI0_MXNA2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI0_MXNA2_2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI0_MXNA2_3 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI0_MXNA3 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI0_MXNA3_2 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI0_MXNA3_3 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI0_MXNA4 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI0_MXNA4_2 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI0_MXNA4_3 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA1_3 ny A VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA2_2 ny B VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA2_3 ny B VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA3 ny C VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA3_2 ny C VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA3_3 ny C VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA4 ny D VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA4_2 ny D VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA4_3 ny D VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.08e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AND4_X1_A7TR Y VDD VNW VPW VSS A B C D
mXI0_MXNA1 ny A XI0_n3 VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI0_MXNA2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI0_MXNA3 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI0_MXNA4 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA3 ny C VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA4 ny D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT AND4_X2_A7TR Y VDD VNW VPW VSS A B C D
mXI0_MXNA1 ny A XI0_n3 VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA3 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA4 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXPA3 ny C VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXPA4 ny D VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AND4_X4_A7TR Y VDD VNW VPW VSS A B C D
mXI0_MXNA4_2 XI0_n1__2 D VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI0_MXNA3_2 XI0_n2__2 C XI0_n1__2 VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI0_MXNA2_2 XI0_n3__2 B XI0_n2__2 VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI0_MXNA1_2 ny A XI0_n3__2 VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI0_MXNA1 ny A XI0_n3 VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI0_MXNA2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI0_MXNA3 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI0_MXNA4 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA3 ny C VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA4 ny D VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AND4_X6_A7TR Y VDD VNW VPW VSS A B C D
mXI0_MXNA4_2 XI0_n1__2 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_2 XI0_n2__2 C XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 XI0_n3__2 B XI0_n2__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 ny A XI0_n3__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 ny A XI0_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA4 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA4 ny D VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA3 ny C VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA2_2 ny B VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA3_2 ny C VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA4_2 ny D VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AND4_X8_A7TR Y VDD VNW VPW VSS A B C D
mXI0_MXNA1 ny A XI0_n3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 ny A XI0_n3 VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI0_MXNA2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI0_MXNA2_2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI0_MXNA3 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI0_MXNA3_2 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI0_MXNA4 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI0_MXNA4_2 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA2_2 ny B VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA3 ny C VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA3_2 ny C VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA4 ny D VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA4_2 ny D VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AND4_XL_A7TR Y VDD VNW VPW VSS A B C D
mXI0_MXNA1 ny A XI0_n3 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 XI0_n3 B XI0_n2 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA3 XI0_n2 C XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA4 XI0_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA3 ny C VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA4 ny D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT ANTENNA_A7TR VDD VNW VPW VSS A
*.CONNECT VNW VDD
*.CONNECT VPW VSS
D_Diode_XD0 VPW A NDIO18DNW  AREA=3.132e-13 PJ=2.24e-06
.ends


.SUBCKT AO21_X1_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNB1 ny A0 XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 ny B0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=4.3e-07
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=4.3e-07
mXI0_MXPA1 ny B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=4.3e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT AO21_X2_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI0_MXNB1 ny A0 XI0_n1 VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI0_MXNA1 ny B0 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXPA1 ny B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AO21_X4_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 ny A0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 ny B0 VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 ny B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AO21_X8_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB1_2 ny A0 XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2_2 XI0_n1__2 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 ny A0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 ny B0 VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA1_2 ny B0 VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2_2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_2 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 ny B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 ny B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AO21_XL_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNB1 ny A0 XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 ny B0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 ny B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT AO22_X1_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
mXI0_MXNB2 XI0_n1B B1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNB1 ny B0 XI0_n1B VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 ny A0 XI0_n1A VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 XI0_n1A A1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPB2 XI0_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPB1 XI0_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 ny A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA2 ny A1 XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT AO22_X2_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
mXI0_MXNB2 XI0_n1B B1 VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI0_MXNB1 ny B0 XI0_n1B VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI0_MXNA1 ny A0 XI0_n1A VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI0_MXNA2 XI0_n1A A1 VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.6e-07
mXI0_MXPB2 XI0_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXPB1 XI0_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXPA1 ny A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXPA2 ny A1 XI0_p1 VNW P18_DNW L=1.8e-07 W=6.6e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AO22_X4_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
mXI0_MXNB2 XI0_n1B B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 ny B0 XI0_n1B VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 ny A0 XI0_n1A VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n1A A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB2 XI0_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1 XI0_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 ny A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 ny A1 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AO22_X8_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
mXI0_MXNB2_2 XI0_n1B__2 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1_2 ny B0 XI0_n1B__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 ny B0 XI0_n1B VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2 XI0_n1B B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 XI0_n1A__2 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 ny A0 XI0_n1A__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 ny A0 XI0_n1A VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n1A A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB2 XI0_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1 XI0_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_2 XI0_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2_2 XI0_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA2 ny A1 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 ny A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 ny A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 ny A1 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends

.SUBCKT AO22_XL_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
mXI0_MXNB2 XI0_n1B B1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNB1 ny B0 XI0_n1B VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 ny A0 XI0_n1A VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 XI0_n1A A1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPB2 XI0_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPB1 XI0_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 ny A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA2 ny A1 XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT AO2B2B_X1_A7TR Y VDD VNW VPW VSS A0 A1N B0 B1N
mXI2_MXNA1 b1 B1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 net34 b1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXNB0 ny B0 net34 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 ny A0 net40 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net40 a1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 a1 A1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI2_MXPA1 b1 B1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 net46 b1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXPB0 net46 B0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 ny A0 net46 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 ny a1 net46 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 a1 A1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT AO2B2B_X2_A7TR Y VDD VNW VPW VSS A0 A1N B0 B1N
mXI2_MXNA1 b1 B1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN12 net34 b1 VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXNB0 ny B0 net34 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN10 ny A0 net40 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN11 net40 a1 VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI1_MXNA1 a1 A1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI2_MXPA1 b1 B1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP10 net46 b1 VDD VNW P18_DNW L=1.8e-07 W=6.6e-07
MXPB0 net46 B0 VDD VNW P18_DNW L=1.8e-07 W=6.6e-07
MXP12 ny A0 net46 VNW P18_DNW L=1.8e-07 W=6.6e-07
MXP11 ny a1 net46 VNW P18_DNW L=1.8e-07 W=6.6e-07
mXI1_MXPA1 a1 A1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AO2B2B_X4_A7TR Y VDD VNW VPW VSS A0 A1N B0 B1N
mXI2_MXNA1 b1 B1N VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
MXN15 net34 b1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNB0 ny B0 net34 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN13 ny A0 net40 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN14 net40 a1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 a1 A1N VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI2_MXPA1 b1 B1N VDD VNW P18_DNW L=1.8e-07 W=5.2e-07
MXP14 net46 b1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXPB0 net46 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP13 ny A0 net46 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP15 ny a1 net46 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 a1 A1N VDD VNW P18_DNW L=1.8e-07 W=5.2e-07
mXI0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AO2B2B_XL_A7TR Y VDD VNW VPW VSS A0 A1N B0 B1N
mXI2_MXNA1 b1 B1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN18 net34 b1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXNB0 ny B0 net34 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN16 ny A0 net40 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN17 net40 a1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 a1 A1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI2_MXPA1 b1 B1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP14 net46 b1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP18 net46 B0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP19 ny A0 net46 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP20 ny a1 net46 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 a1 A1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT AO2B2_X1_A7TR Y VDD VNW VPW VSS A0 A1N B0 B1
MXN8 net051 B1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 ny B0 net051 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 ny A0 net35 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 net35 a1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 a1 A1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXP5 net41 B1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 net41 B0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP7 ny A0 net41 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 ny a1 net41 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 a1 A1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT AO2B2_X2_A7TR Y VDD VNW VPW VSS A0 A1N B0 B1
MXN16 net051 B1 VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN13 ny B0 net051 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN14 ny A0 net35 VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN15 net35 a1 VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI1_MXNA1 a1 A1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP9 net41 B1 VDD VNW P18_DNW L=1.8e-07 W=6.6e-07
MXP13 net41 B0 VDD VNW P18_DNW L=1.8e-07 W=6.6e-07
MXP14 ny A0 net41 VNW P18_DNW L=1.8e-07 W=6.6e-07
MXP15 ny a1 net41 VNW P18_DNW L=1.8e-07 W=6.6e-07
mXI1_MXPA1 a1 A1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AO2B2_X4_A7TR Y VDD VNW VPW VSS A0 A1N B0 B1
MXN5 net051 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNB0 ny B0 net051 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN3 ny A0 net35 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN4 net35 a1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 a1 A1N VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP14 net41 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP18 net41 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP19 ny A0 net41 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP20 ny a1 net41 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 a1 A1N VDD VNW P18_DNW L=1.8e-07 W=5.2e-07
mXI0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AO2B2_XL_A7TR Y VDD VNW VPW VSS A0 A1N B0 B1
MXN7 net051 B1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 ny B0 net051 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 ny A0 net35 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 net35 a1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 a1 A1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXP19 net41 B1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP23 net41 B0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP24 ny A0 net41 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP25 ny a1 net41 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 a1 A1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT AOI211_X1_A7TR Y VDD VNW VPW VSS A0 A1 B0 C0
MXN5 Y A0 net17 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN6 net17 A1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN4 Y C0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXNC0 Y B0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXP6 p1 A0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXPA1 p1 A1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP7 net045 C0 p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP8 Y B0 net045 VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT AOI211_X2_A7TR Y VDD VNW VPW VSS A0 A1 B0 C0
MXN11 Y A0 net17 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN12 net17 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN10 Y C0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNC0 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP12 p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXPA1 p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP13 net045 C0 p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP14 Y B0 net045 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI211_X4_A7TR Y VDD VNW VPW VSS A0 A1 B0 C0
MXN16_2 net17__2 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN15_2 Y A0 net17__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN15 Y A0 net17 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN16 net17 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN14 Y C0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN13 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN13_2 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN14_2 Y C0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXPA1 p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP15 p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP15_2 p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXPA1_2 p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP16_2 net045__2 C0 p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP17_2 Y B0 net045__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP17 Y B0 net045 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP16 net045 C0 p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI211_XL_A7TR Y VDD VNW VPW VSS A0 A1 B0 C0
MXN11 Y A0 net17 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN12 net17 A1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 Y C0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXNC0 Y B0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXP12 p1 A0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXPA1 p1 A1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP13 net045 C0 p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP14 Y B0 net045 VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT AOI21B_X1_A7TR Y VDD VNW VPW VSS A0 A1 B0N
mXI0_MXNA2 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI0_MXNA1 a0a1 A1 XI0_n1 VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI1_MXNA1 ny a0a1 XI1_n1 VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI1_MXNA2 XI1_n1 B0N VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI2_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA2 a0a1 A0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 a0a1 A1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 ny a0a1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2 ny B0N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI2_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT AOI21B_X2_A7TR Y VDD VNW VPW VSS A0 A1 B0N
mXI0_MXNA2 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI0_MXNA1 a0a1 A1 XI0_n1 VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI1_MXNA1 ny a0a1 XI1_n1 VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI1_MXNA2 XI1_n1 B0N VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI2_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA2 a0a1 A0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 a0a1 A1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 ny a0a1 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXPA2 ny B0N VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI2_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI21B_X4_A7TR Y VDD VNW VPW VSS A0 A1 B0N
mXI0_MXNA2 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
mXI0_MXNA1 a0a1 A1 XI0_n1 VPW N18_DNW L=1.8e-07 W=3.9e-07
mXI1_MXNA1 ny a0a1 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2 XI1_n1 B0N VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI2_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI2_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA2 a0a1 A0 VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI0_MXPA1 a0a1 A1 VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI1_MXPA1 ny a0a1 VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI1_MXPA2 ny B0N VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI2_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI2_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI21B_X8_A7TR Y VDD VNW VPW VSS A0 A1 B0N
mXI0_MXNA1 a0a1 A1 XI0_n1 VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI0_MXNA2 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI1_MXNA2_2 XI1_n1__2 B0N VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 ny a0a1 XI1_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 ny a0a1 XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2 XI1_n1 B0N VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI2_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI2_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI2_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI2_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 a0a1 A1 VDD VNW P18_DNW L=1.8e-07 W=8.9e-07
mXI0_MXPA2 a0a1 A0 VDD VNW P18_DNW L=1.8e-07 W=8.9e-07
mXI1_MXPA2 ny B0N VDD VNW P18_DNW L=1.8e-07 W=1.06e-06
mXI1_MXPA1 ny a0a1 VDD VNW P18_DNW L=1.8e-07 W=1.06e-06
mXI1_MXPA1_2 ny a0a1 VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA2_2 ny B0N VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI2_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI2_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI2_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI2_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT AOI21B_XL_A7TR Y VDD VNW VPW VSS A0 A1 B0N
mXI0_MXNA2 XI0_n1 A0 VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI0_MXNA1 a0a1 A1 XI0_n1 VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI1_MXNA1 ny a0a1 XI1_n1 VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI1_MXNA2 XI1_n1 B0N VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI2_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA2 a0a1 A0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 a0a1 A1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 ny a0a1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2 ny B0N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI2_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT AOI21_X1_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNB1 Y A0 XI0_n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA1 Y B0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPA1 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT AOI21_X2_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 Y A0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends

.SUBCKT AOI21_X3_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB1_2 Y A0 XI0_n1__2 VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNB2_2 XI0_n1__2 A1 VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNB1 Y A0 XI0_n1 VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA1 Y B0 VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA1_2 Y B0 VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPB2_2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPB1_2 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1e-06
mXI0_MXPA1 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI0_MXPA1_2 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=9.9e-07
.ends


.SUBCKT AOI21_X4_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB1_2 Y A0 XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2_2 XI0_n1__2 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 Y A0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2_2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_2 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI21_X6_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNA1 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2_2 XI0_n1__2 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1_2 Y A0 XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1_3 Y A0 XI0_n1__3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2_3 XI0_n1__3 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 Y A0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_2 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2_2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2_3 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_3 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI21_X8_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNA1 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2_2 XI0_n1__2 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1_2 Y A0 XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1_3 Y A0 XI0_n1__3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2_3 XI0_n1__3 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2_4 XI0_n1__4 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1_4 Y A0 XI0_n1__4 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 Y A0 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPB1_2 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2_2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2_3 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_3 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_4 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2_4 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT AOI21_XL_A7TR Y VDD VNW VPW VSS A0 A1 B0
mXI0_MXNB2 XI0_n1 A1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNB1 Y A0 XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 Y B0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA1 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT AOI221_X1_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1 C0
MXN7 Y B0 net26 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN10 net26 B1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN9 net17 A1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN8 Y A0 net17 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN6 Y C0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXP5 p1 B0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP6 p1 B1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP7 p2 A1 p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP9 p2 A0 p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP8 Y C0 p2 VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT AOI221_X2_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1 C0
MXN15 Y B0 net26 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN18 net26 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN17 net17 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN16 Y A0 net17 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6 Y C0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP5 p1 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP14 p1 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP15 p2 A1 p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP16 p2 A0 p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP17 Y C0 p2 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI221_X4_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1 C0
MXN22_2 net26__2 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN19_2 Y B0 net26__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN19 Y B0 net26 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN22 net26 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN21_2 net17__2 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN20_2 Y A0 net17__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN20 Y A0 net17 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN21 net17 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6 Y C0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6_2 Y C0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP18 p1 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP5 p1 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP5_2 p1 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP18_2 p1 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP19 p2 A1 p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP20 p2 A0 p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP20_2 p2 A0 p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP19_2 p2 A1 p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP21 Y C0 p2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP21_2 Y C0 p2 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI221_XL_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1 C0
MXN16 Y B0 net26 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN19 net26 B1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN18 net17 A1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN17 Y A0 net17 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN11 Y C0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXP10 p1 B0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP15 p1 B1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP16 p2 A1 p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP17 p2 A0 p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP18 Y C0 p2 VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT AOI222_X1_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1 C0 C1
MXN6 Y C0 net29 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN4 net29 C1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN3 net26 B1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN0 Y B0 net26 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN1 Y A0 net17 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN2 net17 A1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXP5 p1 C0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP6 p1 C1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP7 p2 B1 p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP8 p2 B0 p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP9 Y A0 p2 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP10 Y A1 p2 VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT AOI222_X2_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1 C0 C1
MXN11 Y C0 net29 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN15 net29 C1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN14 net26 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6 Y B0 net26 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN12 Y A0 net17 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN13 net17 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP17 p1 C0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP11 p1 C1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP19 p2 B1 p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP18 p2 B0 p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP21 Y A0 p2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP20 Y A1 p2 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI222_X4_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1 C0 C1
MXN11_2 Y C0 net29__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN21_2 net29__2 C1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN21 net29 C1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN11 Y C0 net29 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN17_2 Y B0 net26__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN20_2 net26__2 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN20 net26 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN17 Y B0 net26 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN18_2 Y A0 net17__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN19_2 net17__2 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN19 net17 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN18 Y A0 net17 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP22 p1 C0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP17 p1 C1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP17_2 p1 C1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP22_2 p1 C0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP23 p2 B0 p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP24 p2 B1 p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP24_2 p2 B1 p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP23_2 p2 B0 p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP26 Y A0 p2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP25 Y A1 p2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP25_2 Y A1 p2 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP26_2 Y A0 p2 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI222_XL_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1 C0 C1
MXN13 Y C0 net29 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN14 net29 C1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN11 net26 B1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN12 Y B0 net26 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 Y A0 net17 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net17 A1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXP17 p1 C0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP11 p1 C1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP19 p2 B1 p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP18 p2 B0 p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP21 Y A0 p2 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP20 Y A1 p2 VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT AOI22_X1_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
mXI0_MXNB2 XI0_n1B B1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNB1 Y B0 XI0_n1B VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA1 Y A0 XI0_n1A VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA2 XI0_n1A A1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPB2 XI0_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPB1 XI0_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPA1 Y A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPA2 Y A1 XI0_p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT AOI22_X2_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
mXI0_MXNB2 XI0_n1B B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 Y B0 XI0_n1B VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A0 XI0_n1A VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n1A A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB2 XI0_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1 XI0_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 Y A1 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI22_X4_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
mXI0_MXNB2_2 XI0_n1B__2 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1_2 Y B0 XI0_n1B__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 Y B0 XI0_n1B VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2 XI0_n1B B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 XI0_n1A__2 A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A0 XI0_n1A__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A0 XI0_n1A VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n1A A1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB2 XI0_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1 XI0_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_2 XI0_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2_2 XI0_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 Y A1 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 Y A1 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI22_XL_A7TR Y VDD VNW VPW VSS A0 A1 B0 B1
mXI0_MXNB2 XI0_n1B B1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNB1 Y B0 XI0_n1B VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 Y A0 XI0_n1A VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 XI0_n1A A1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPB2 XI0_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPB1 XI0_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA1 Y A0 XI0_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA2 Y A1 XI0_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT AOI2B1_X1_A7TR Y VDD VNW VPW VSS A0 A1N B0
mXI0_MXNA1 a1 A1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 net022 a1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXNA0 Y A0 net022 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN4 Y B0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA1 a1 A1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 net36 a1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXPA0 net36 A0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP5 Y B0 net36 VNW P18_DNW L=1.8e-07 W=8.2e-07
.ends

.SUBCKT AOI2B1_X2_A7TR Y VDD VNW VPW VSS A0 A1N B0
mXI0_MXNA1 a1 A1N VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
MXN8 net022 a1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNA0 Y A0 net022 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN7 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 a1 A1N VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
MXP10 net36 a1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXPA0 net36 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP11 Y B0 net36 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI2B1_X4_A7TR Y VDD VNW VPW VSS A0 A1N B0
mXI0_MXNA1 a1 A1N VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN9_2 net022__2 a1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNA0_2 Y A0 net022__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNA0 Y A0 net022 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN9 net022 a1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN10 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN10_2 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 a1 A1N VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
MXP10 net36 a1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXPA0 net36 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXPA0_2 net36 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP10_2 net36 a1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP11 Y B0 net36 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP11_2 Y B0 net36 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI2B1_X8_A7TR Y VDD VNW VPW VSS A0 A1N B0
mXI0_MXNA1 a1 A1N VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN11_2 net022__2 a1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNA0_2 Y A0 net022__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNA0_3 Y A0 net022__3 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN11_3 net022__3 a1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN11_4 net022__4 a1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNA0_4 Y A0 net022__4 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNA0 Y A0 net022 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN11 net022 a1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN12 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN12_2 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN12_3 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN12_4 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 a1 A1N VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP12 net36 a1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXPA0 net36 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXPA0_2 net36 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP12_2 net36 a1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP12_3 net36 a1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXPA0_3 net36 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXPA0_4 net36 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP12_4 net36 a1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP13 Y B0 net36 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP13_2 Y B0 net36 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP13_3 Y B0 net36 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP13_4 Y B0 net36 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI2B1_XL_A7TR Y VDD VNW VPW VSS A0 A1N B0
mXI0_MXNA1 a1 A1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 net022 a1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXNA0 Y A0 net022 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 Y B0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA1 a1 A1N VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 net36 a1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXPA0 net36 A0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP9 Y B0 net36 VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT AOI2BB1_X1_A7TR Y VDD VNW VPW VSS A0N A1N B0
mXI23_MXNA1 nmin A0N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI23_MXNA2 nmin A1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI24_MXNA2 Y B0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI24_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI23_MXPA1 nmin A0N XI23_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI23_MXPA2 XI23_p1 A1N VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI24_MXPA2 XI24_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI24_MXPA1 Y nmin XI24_p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT AOI2BB1_X2_A7TR Y VDD VNW VPW VSS A0N A1N B0
mXI23_MXNA1 nmin A0N VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI23_MXNA2 nmin A1N VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI24_MXNA2 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI24_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI23_MXPA1 nmin A0N XI23_p1 VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI23_MXPA2 XI23_p1 A1N VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI24_MXPA2 XI24_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI24_MXPA1 Y nmin XI24_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI2BB1_X4_A7TR Y VDD VNW VPW VSS A0N A1N B0
mXI23_MXNA1 nmin A0N VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI23_MXNA2 nmin A1N VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI24_MXNA2 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI24_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI24_MXNA1_2 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI24_MXNA2_2 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI23_MXPA1 nmin A0N XI23_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI23_MXPA2 XI23_p1 A1N VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI24_MXPA2_2 XI24_p1__2 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI24_MXPA1_2 Y nmin XI24_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI24_MXPA1 Y nmin XI24_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI24_MXPA2 XI24_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI2BB1_X8_A7TR Y VDD VNW VPW VSS A0N A1N B0
mXI23_MXNA2 nmin A1N VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI23_MXNA1 nmin A0N VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI23_MXNA1_2 nmin A0N VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI23_MXNA2_2 nmin A1N VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI24_MXNA2 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI24_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI24_MXNA1_2 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI24_MXNA2_2 Y B0 VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI24_MXNA2_3 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI24_MXNA1_3 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI24_MXNA1_4 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI24_MXNA2_4 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI23_MXPA2_2 XI23_p1__2 A1N VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI23_MXPA1_2 nmin A0N XI23_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI23_MXPA1 nmin A0N XI23_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI23_MXPA2 XI23_p1 A1N VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI24_MXPA2_2 XI24_p1__2 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI24_MXPA1_2 Y nmin XI24_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI24_MXPA1_3 Y nmin XI24_p1__3 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI24_MXPA2_3 XI24_p1__3 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI24_MXPA2_4 XI24_p1__4 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI24_MXPA1_4 Y nmin XI24_p1__4 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI24_MXPA1 Y nmin XI24_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI24_MXPA2 XI24_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI2BB1_XL_A7TR Y VDD VNW VPW VSS A0N A1N B0
mXI23_MXNA1 nmin A0N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI23_MXNA2 nmin A1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI24_MXNA2 Y B0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI24_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI23_MXPA1 nmin A0N XI23_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI23_MXPA2 XI23_p1 A1N VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI24_MXPA2 XI24_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI24_MXPA1 Y nmin XI24_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT AOI2BB2_X1_A7TR Y VDD VNW VPW VSS A0N A1N B0 B1
mXI28_MXNA2 nmin A1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI28_MXNA1 nmin A0N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI27_MXNB2 XI27_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI27_MXNB1 Y B0 XI27_n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI27_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI28_MXPA2 XI28_p1 A1N VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI28_MXPA1 nmin A0N XI28_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI27_MXPB2 XI27_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI27_MXPB1 XI27_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI27_MXPA1 Y nmin XI27_p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT AOI2BB2_X2_A7TR Y VDD VNW VPW VSS A0N A1N B0 B1
mXI28_MXNA2 nmin A1N VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI28_MXNA1 nmin A0N VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI27_MXNB2 XI27_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI27_MXNB1 Y B0 XI27_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI27_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI28_MXPA2 XI28_p1 A1N VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI28_MXPA1 nmin A0N XI28_p1 VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI27_MXPB2 XI27_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPB1 XI27_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPA1 Y nmin XI27_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI2BB2_X4_A7TR Y VDD VNW VPW VSS A0N A1N B0 B1
mXI28_MXNA2 nmin A1N VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI28_MXNA1 nmin A0N VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI27_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI27_MXNA1_2 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI27_MXNB2_2 XI27_n1__2 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI27_MXNB1_2 Y B0 XI27_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI27_MXNB1 Y B0 XI27_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI27_MXNB2 XI27_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI28_MXPA2 XI28_p1 A1N VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI28_MXPA1 nmin A0N XI28_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPA1 Y nmin XI27_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPA1_2 Y nmin XI27_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPB2 XI27_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPB1 XI27_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPB1_2 XI27_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPB2_2 XI27_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI2BB2_X8_A7TR Y VDD VNW VPW VSS A0N A1N B0 B1
mXI28_MXNA1 nmin A0N VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI28_MXNA2 nmin A1N VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI28_MXNA2_2 nmin A1N VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI28_MXNA1_2 nmin A0N VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI27_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI27_MXNA1_2 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI27_MXNA1_3 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI27_MXNA1_4 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI27_MXNB2_2 XI27_n1__2 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI27_MXNB1_2 Y B0 XI27_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI27_MXNB1_3 Y B0 XI27_n1__3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI27_MXNB2_3 XI27_n1__3 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI27_MXNB2_4 XI27_n1__4 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI27_MXNB1_4 Y B0 XI27_n1__4 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI27_MXNB1 Y B0 XI27_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI27_MXNB2 XI27_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI28_MXPA1_2 nmin A0N XI28_p1__2 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI28_MXPA2_2 XI28_p1__2 A1N VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI28_MXPA2 XI28_p1 A1N VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI28_MXPA1 nmin A0N XI28_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPA1 Y nmin XI27_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPA1_2 Y nmin XI27_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPA1_3 Y nmin XI27_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPA1_4 Y nmin XI27_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPB2 XI27_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPB1 XI27_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI27_MXPB1_2 XI27_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPB2_2 XI27_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPB2_3 XI27_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPB1_3 XI27_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPB1_4 XI27_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI27_MXPB2_4 XI27_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT AOI2BB2_XL_A7TR Y VDD VNW VPW VSS A0N A1N B0 B1
mXI28_MXNA2 nmin A1N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI28_MXNA1 nmin A0N VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI27_MXNB2 XI27_n1 B1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI27_MXNB1 Y B0 XI27_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI27_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI28_MXPA2 XI28_p1 A1N VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI28_MXPA1 nmin A0N XI28_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI27_MXPB2 XI27_p1 B1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI27_MXPB1 XI27_p1 B0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI27_MXPA1 Y nmin XI27_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT AOI31_X1_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0
mXI0_MXNB3 XI0_n1 A2 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNB2 XI0_n2 A1 XI0_n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNB1 Y A0 XI0_n2 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA1 Y B0 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPB3 XI0_p1 A2 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPA1 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT AOI31_X2_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0
mXI0_MXNB3 XI0_n1 A2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2 XI0_n2 A1 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 Y A0 XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB3 XI0_p1 A2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI31_X4_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0
mXI0_MXNB1_2 Y A0 XI0_n2__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2_2 XI0_n2__2 A1 XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB3_2 XI0_n1__2 A2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB3 XI0_n1 A2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2 XI0_n2 A1 XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 Y A0 XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y B0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPB3 XI0_p1 A2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB3_2 XI0_p1 A2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2_2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_2 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI31_XL_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0
mXI0_MXNB3 XI0_n1 A2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNB2 XI0_n2 A1 XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNB1 Y A0 XI0_n2 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 Y B0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPB3 XI0_p1 A2 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA1 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT AOI32_X1_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0 B1
mXI0_MXNB3 XI0_n1B A2 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNB2 XI0_n2B A1 XI0_n1B VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNB1 Y A0 XI0_n2B VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA1 Y B0 XI0_n1A VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA2 XI0_n1A B1 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPB3 XI0_p1 A2 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPA1 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPA2 Y B1 XI0_p1 VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT AOI32_X2_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0 B1
mXI0_MXNB3 XI0_n1B A2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2 XI0_n2B A1 XI0_n1B VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 Y A0 XI0_n2B VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y B0 XI0_n1A VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n1A B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB3 XI0_p1 A2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 Y B1 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI32_X4_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0 B1
mXI0_MXNB1_2 Y A0 XI0_n2B__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2_2 XI0_n2B__2 A1 XI0_n1B__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB3_2 XI0_n1B__2 A2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB3 XI0_n1B A2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB2 XI0_n2B A1 XI0_n1B VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNB1 Y A0 XI0_n2B VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y B0 XI0_n1A__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 XI0_n1A__2 B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n1A B1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y B0 XI0_n1A VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB3 XI0_p1 A2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB3_2 XI0_p1 A2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB2_2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPB1_2 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 Y B1 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 Y B1 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI32_XL_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0 B1
mXI0_MXNB3 XI0_n1B A2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNB2 XI0_n2B A1 XI0_n1B VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNB1 Y A0 XI0_n2B VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 Y B0 XI0_n1A VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 XI0_n1A B1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPB3 XI0_p1 A2 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPB2 XI0_p1 A1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPB1 XI0_p1 A0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA1 Y B0 XI0_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA2 Y B1 XI0_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT AOI33_X1_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0 B1 B2
MXN8 net55 B2 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN7 net49 B1 net55 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN6 Y B0 net49 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXNA0 Y A0 net43 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN9 net43 A1 net40 VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN10 net40 A2 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXP12 net057 B2 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP11 net057 B1 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXPB0 net057 B0 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP15 Y A0 net057 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP14 Y A1 net057 VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP13 Y A2 net057 VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT AOI33_X2_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0 B1 B2
MXN18 net55 B2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN17 net49 B1 net55 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN16 Y B0 net49 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNA0 Y A0 net43 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN19 net43 A1 net40 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN20 net40 A2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP12 net057 B2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP11 net057 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXPB0 net057 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP15 Y A0 net057 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP14 Y A1 net057 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP13 Y A2 net057 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT AOI33_X4_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0 B1 B2
MXN26_2 Y B0 net49__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN27_2 net49__2 B1 net55__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN28_2 net55__2 B2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN28 net55 B2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN27 net49 B1 net55 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN26 Y B0 net49 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNA0_2 Y A0 net43__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN29_2 net43__2 A1 net40__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN30_2 net40__2 A2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN30 net40 A2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN29 net43 A1 net40 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXNA0 Y A0 net43 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP21 net057 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP22 net057 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP23 net057 B2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP23_2 net057 B2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP22_2 net057 B1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP21_2 net057 B0 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP26 Y A0 net057 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP25 Y A1 net057 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP24 Y A2 net057 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP24_2 Y A2 net057 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP25_2 Y A1 net057 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP26_2 Y A0 net057 VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends

.SUBCKT AOI33_XL_A7TR Y VDD VNW VPW VSS A0 A1 A2 B0 B1 B2
MXN18 net55 B2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN17 net49 B1 net55 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN16 Y B0 net49 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXNA0 Y A0 net43 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN20 net43 A1 net40 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN19 net40 A2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXP22 net057 B2 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP21 net057 B1 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXPB0 net057 B0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP25 Y A0 net057 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP24 Y A1 net057 VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP23 Y A2 net057 VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT BUF_X10_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=8.6e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=8.6e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT BUF_X12_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI0_MXNA1_3 ny A VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_3 ny A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT BUF_X14_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=8e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=8e-07
mXI0_MXNA1_3 ny A VSS VPW N18_DNW L=1.8e-07 W=8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_7 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI0_MXPA1_3 ny A VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_7 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT BUF_X16_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI0_MXNA1_3 ny A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1_4 ny A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_7 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_8 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_3 ny A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_4 ny A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_7 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_8 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT BUF_X18_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=7.7e-07
mXI0_MXNA1_3 ny A VSS VPW N18_DNW L=1.8e-07 W=7.7e-07
mXI0_MXNA1_4 ny A VSS VPW N18_DNW L=1.8e-07 W=7.7e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_7 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_8 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_9 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
mXI0_MXPA1_3 ny A VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
mXI0_MXPA1_4 ny A VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_7 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_8 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_9 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT BUF_X20_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
mXI0_MXNA1_3 ny A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
mXI0_MXNA1_4 ny A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI1_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_7 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_8 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_9 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_10 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI0_MXPA1_3 ny A VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI0_MXPA1_4 ny A VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_7 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_8 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_9 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_10 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT BUF_X24_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI0_MXNA1_3 ny A VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI0_MXNA1_4 ny A VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI0_MXNA1_5 ny A VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_7 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI1_MXNA1_8 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_9 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_10 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_11 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_12 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
mXI0_MXPA1_3 ny A VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
mXI0_MXPA1_4 ny A VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
mXI0_MXPA1_5 ny A VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_7 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA1_8 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_9 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_10 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_11 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_12 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT BUF_X2_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT BUF_X32_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 ny A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 ny A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_5 ny A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1_6 ny A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI1_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_7 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_8 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_9 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_10 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_11 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_12 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_13 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_14 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_15 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_16 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 ny A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 ny A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_5 ny A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_6 ny A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_7 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_8 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_9 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_10 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_11 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_12 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_13 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_14 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_15 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_16 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT BUF_X3_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT BUF_X4_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT BUF_X5_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
.ends


.SUBCKT BUF_X6_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT BUF_X8_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT CLKAND2_X12_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2_2 XI0_n1__2 B VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI0_MXNA1_2 ny A XI0_n1__2 VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI0_MXNA1 ny A XI0_n1 VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=1.51e-06
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.51e-06
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.51e-06
mXI0_MXPA2_2 ny B VDD VNW P18_DNW L=1.8e-07 W=1.51e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT CLKAND2_X16_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2_2 XI0_n1__2 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 ny A XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 ny A XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI1_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 ny B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 ny A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_3 ny B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.51e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.51e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.51e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.51e-06
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.51e-06
mXI1_MXPA1_7 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends

.SUBCKT CLKAND2_X2_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA1 ny A XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=5.4e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKAND2_X3_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA1 ny A XI0_n1 VPW N18_DNW L=1.8e-07 W=3.5e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=8.1e-07
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=8.1e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
.ends


.SUBCKT CLKAND2_X4_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA1 ny A XI0_n1 VPW N18_DNW L=1.8e-07 W=4.6e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=4.6e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.08e-06
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=1.08e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKAND2_X6_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA1 ny A XI0_n1 VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.5e-06
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=1.5e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKAND2_X8_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA1 ny A XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXPA2 ny B VDD VNW P18_DNW L=1.8e-07 W=1.08e-06
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.08e-06
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.08e-06
mXI0_MXPA2_2 ny B VDD VNW P18_DNW L=1.8e-07 W=1.08e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKBUF_X12_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.5e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.5e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.5e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.5e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.5e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.65e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.65e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.65e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.65e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKBUF_X16_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_7 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.6e-07
.ends


.SUBCKT CLKBUF_X1_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
.ends


.SUBCKT CLKBUF_X20_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1_3 ny A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_7 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_8 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 ny A VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_7 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_8 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKBUF_X24_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI0_MXNA1_3 ny A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_7 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_8 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_9 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_10 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI0_MXPA1_3 ny A VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_7 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_8 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_9 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_10 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKBUF_X2_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKBUF_X32_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI0_MXNA1_3 ny A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI0_MXNA1_4 ny A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_7 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_8 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_9 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_10 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_11 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_12 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1_13 Y ny VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI0_MXPA1_3 ny A VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI0_MXPA1_4 ny A VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_7 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_8 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_9 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_10 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_11 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_12 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI1_MXPA1_13 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKBUF_X3_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
.ends


.SUBCKT CLKBUF_X40_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI0_MXNA1_2 ny A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI0_MXNA1_3 ny A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI0_MXNA1_4 ny A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI0_MXNA1_5 ny A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI1_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI1_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI1_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI1_MXNA1_7 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI1_MXNA1_8 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI1_MXNA1_9 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI1_MXNA1_10 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI1_MXNA1_11 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI1_MXNA1_12 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI1_MXNA1_13 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI1_MXNA1_14 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI1_MXNA1_15 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI0_MXPA1_3 ny A VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI0_MXPA1_4 ny A VDD VNW P18_DNW L=1.8e-07 W=1.6e-06
mXI0_MXPA1_5 ny A VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI1_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI1_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI1_MXPA1_7 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI1_MXPA1_8 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI1_MXPA1_9 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI1_MXPA1_10 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI1_MXPA1_11 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI1_MXPA1_12 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI1_MXPA1_13 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI1_MXPA1_14 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI1_MXPA1_15 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.56e-06
mXI1_MXPA1_16 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
.ends


.SUBCKT CLKBUF_X4_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=3.3e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKBUF_X6_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKBUF_X8_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 ny A VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI1_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI1_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI1_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI0_MXPA1 ny A VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
mXI0_MXPA1_2 ny A VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
mXI1_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT CLKINV_X12_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_6 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT CLKINV_X16_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA1_5 Y A VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA1_6 Y A VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.54e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.54e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.54e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=1.54e-06
mXI0_MXPA1_6 Y A VDD VNW P18_DNW L=1.8e-07 W=1.54e-06
mXI0_MXPA1_7 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKINV_X1_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=7e-07
.ends


.SUBCKT CLKINV_X20_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_5 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_6 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_7 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_8 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_6 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_7 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_8 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKINV_X24_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI0_MXNA1_5 Y A VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI0_MXNA1_6 Y A VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI0_MXNA1_7 Y A VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI0_MXNA1_8 Y A VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI0_MXNA1_9 Y A VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI0_MXNA1_10 Y A VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.61e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.61e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.61e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=1.61e-06
mXI0_MXPA1_6 Y A VDD VNW P18_DNW L=1.8e-07 W=1.61e-06
mXI0_MXPA1_7 Y A VDD VNW P18_DNW L=1.8e-07 W=1.61e-06
mXI0_MXPA1_8 Y A VDD VNW P18_DNW L=1.8e-07 W=1.61e-06
mXI0_MXPA1_9 Y A VDD VNW P18_DNW L=1.8e-07 W=1.61e-06
mXI0_MXPA1_10 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKINV_X2_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKINV_X32_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_5 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_6 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_7 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_8 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_9 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_10 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_11 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_12 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_13 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_6 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_7 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_8 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_9 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_10 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_11 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_12 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_13 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKINV_X3_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
.ends


.SUBCKT CLKINV_X40_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_5 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_6 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_7 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_8 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_9 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_10 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_11 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_12 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_13 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_14 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_15 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_16 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXNA1_17 Y A VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_6 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_7 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_8 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_9 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_10 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_11 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_12 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_13 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_14 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_15 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_16 Y A VDD VNW P18_DNW L=1.8e-07 W=1.58e-06
mXI0_MXPA1_17 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends

.SUBCKT CLKINV_X4_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKINV_X6_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKINV_X8_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=7e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=7e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=7e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKMX2_X12_A7TR Y VDD VNW VPW VSS A B S0
mX_g1_MXNA1 ns0 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI7_MXNOE ny S0 nb VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI6_MXNOE ny ns0 na VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g2_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=7e-07
mX_g0_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=7e-07
mX_g0_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=7e-07
mX_g0_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=7e-07
mX_g1_MXPA1 ns0 S0 VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mX_g3_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI7_MXPOEN ny ns0 nb VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI6_MXPOEN ny S0 na VNW P18_DNW L=1.8e-07 W=1.16e-06
mX_g2_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.5e-06
mX_g0_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.5e-06
mX_g0_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.5e-06
mX_g0_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKMX2_X16_A7TR Y VDD VNW VPW VSS A B S0
mX_g1_MXNA1 ns0 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI7_MXNOE ny S0 nb VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI6_MXNOE ny ns0 na VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g2_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
mX_g0_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
mX_g0_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
mX_g0_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
mX_g0_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
mX_g0_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
mX_g1_MXPA1 ns0 S0 VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mX_g3_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI7_MXPOEN ny ns0 nb VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI6_MXPOEN ny S0 na VNW P18_DNW L=1.8e-07 W=1.16e-06
mX_g2_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.59e-06
mX_g0_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.59e-06
mX_g0_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.59e-06
mX_g0_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.59e-06
mX_g0_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.59e-06
mX_g0_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKMX2_X2_A7TR Y VDD VNW VPW VSS A B S0
mX_g1_MXNA1 ns0 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXNOE ny S0 nb VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI6_MXNOE ny ns0 na VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g1_MXPA1 ns0 S0 VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mX_g3_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=1.08e-06
mXI7_MXPOEN ny ns0 nb VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI6_MXPOEN ny S0 na VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g2_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKMX2_X3_A7TR Y VDD VNW VPW VSS A B S0
mX_g1_MXNA1 ns0 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI7_MXNOE ny S0 nb VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI6_MXNOE ny ns0 na VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g2_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mX_g1_MXPA1 ns0 S0 VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mX_g3_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI7_MXPOEN ny ns0 nb VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI6_MXPOEN ny S0 na VNW P18_DNW L=1.8e-07 W=1.16e-06
mX_g2_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g0_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT CLKMX2_X4_A7TR Y VDD VNW VPW VSS A B S0
mX_g1_MXNA1 ns0 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI7_MXNOE ny S0 nb VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI6_MXNOE ny ns0 na VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g2_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXPA1 ns0 S0 VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mX_g3_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI7_MXPOEN ny ns0 nb VNW P18_DNW L=1.8e-07 W=1.06e-06
mXI6_MXPOEN ny S0 na VNW P18_DNW L=1.8e-07 W=1.16e-06
mX_g2_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKMX2_X6_A7TR Y VDD VNW VPW VSS A B S0
mX_g1_MXNA1 ns0 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI7_MXNOE ny S0 nb VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI6_MXNOE ny ns0 na VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g2_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mX_g0_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mX_g1_MXPA1 ns0 S0 VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mX_g3_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI7_MXPOEN ny ns0 nb VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI6_MXPOEN ny S0 na VNW P18_DNW L=1.8e-07 W=1.16e-06
mX_g2_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKMX2_X8_A7TR Y VDD VNW VPW VSS A B S0
mX_g1_MXNA1 ns0 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 nb B VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI7_MXNOE ny S0 nb VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI6_MXNOE ny ns0 na VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g2_MXNA1 na A VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g0_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g0_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g1_MXPA1 ns0 S0 VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mX_g3_MXPA1 nb B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI7_MXPOEN ny ns0 nb VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI6_MXPOEN ny S0 na VNW P18_DNW L=1.8e-07 W=1.16e-06
mX_g2_MXPA1 na A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKNAND2_X12_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA1_2 Y A XI0_n1__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXNA2_2 XI0_n1__2 B VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXNA2_3 XI0_n1__3 B VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXNA1_3 Y A XI0_n1__3 VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXNA1_4 Y A XI0_n1__4 VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXNA2_4 XI0_n1__4 B VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXNA1 Y A XI0_n1 VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2_3 Y B VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2_4 Y B VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2_5 Y B VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
.ends


.SUBCKT CLKNAND2_X16_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA1_2 Y A XI0_n1__2 VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA2_2 XI0_n1__2 B VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA2_3 XI0_n1__3 B VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA1_3 Y A XI0_n1__3 VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA1_4 Y A XI0_n1__4 VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA2_4 XI0_n1__4 B VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA2_5 XI0_n1__5 B VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA1_5 Y A XI0_n1__5 VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA1_6 Y A XI0_n1__6 VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA2_6 XI0_n1__6 B VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA1 Y A XI0_n1 VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
mXI0_MXPA2_3 Y B VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
mXI0_MXPA2_4 Y B VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
mXI0_MXPA2_5 Y B VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
mXI0_MXPA1_6 Y A VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
mXI0_MXPA2_6 Y B VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
mXI0_MXPA2_7 Y B VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
mXI0_MXPA1_7 Y A VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
.ends


.SUBCKT CLKNAND2_X2_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
mXI0_MXNA1 Y A XI0_n1 VPW N18_DNW L=1.8e-07 W=5.7e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=9e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=9e-07
.ends


.SUBCKT CLKNAND2_X4_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA1_2 Y A XI0_n1__2 VPW N18_DNW L=1.8e-07 W=5.7e-07
mXI0_MXNA2_2 XI0_n1__2 B VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
mXI0_MXNA1 Y A XI0_n1 VPW N18_DNW L=1.8e-07 W=5.7e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=9e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=9e-07
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=9e-07
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=9e-07
.ends


.SUBCKT CLKNAND2_X8_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA1_2 Y A XI0_n1__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXNA2_2 XI0_n1__2 B VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXNA2_3 XI0_n1__3 B VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXNA1_3 Y A XI0_n1__3 VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXNA1 Y A XI0_n1 VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=7.05e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=7.05e-07
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=7.05e-07
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=7.05e-07
mXI0_MXPA2_3 Y B VDD VNW P18_DNW L=1.8e-07 W=9.95e-07
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=9.95e-07
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=9.95e-07
mXI0_MXPA2_4 Y B VDD VNW P18_DNW L=1.8e-07 W=9.95e-07
.ends


.SUBCKT CLKXOR2_X12_A7TR Y VDD VNW VPW VSS A B
mX_g3_MXNA1 nB B VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g3_MXNA1_2 nB B VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g3_MXNA1_3 nB B VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g3_MXNA1_4 nB B VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g2_MXNA1 bB nB VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g2_MXNA1_2 bB nB VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g2_MXNA1_3 bB nB VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI6_MXNOE ny A bB VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI6_MXNOE_2 ny A bB VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI6_MXNOE_3 ny A bB VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI5_MXNOE ny nA nB VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI5_MXNOE_2 ny nA nB VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI5_MXNOE_3 ny nA nB VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g1_MXNA1 nA A VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
mX_g0_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
mX_g0_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
mX_g0_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
mX_g0_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
mX_g3_MXPA1 nB B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g3_MXPA1_2 nB B VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g3_MXPA1_3 nB B VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g3_MXPA1_4 nB B VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g2_MXPA1 bB nB VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g2_MXPA1_2 bB nB VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g2_MXPA1_3 bB nB VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mXI6_MXPOEN ny nA bB VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI6_MXPOEN_2 ny nA bB VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI6_MXPOEN_3 ny nA bB VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI6_MXPOEN_4 ny nA bB VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI5_MXPOEN ny A nB VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI5_MXPOEN_2 ny A nB VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI5_MXPOEN_3 ny A nB VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI5_MXPOEN_4 ny A nB VNW P18_DNW L=1.8e-07 W=1.12e-06
mX_g1_MXPA1 nA A VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g0_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g0_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g0_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g0_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKXOR2_X16_A7TR Y VDD VNW VPW VSS A B
mX_g3_MXNA1 net52 B VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g3_MXNA1_2 net52 B VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g3_MXNA1_3 net52 B VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g3_MXNA1_4 net52 B VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g3_MXNA1_5 net52 B VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g2_MXNA1 bB net52 VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g2_MXNA1_2 bB net52 VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g2_MXNA1_3 bB net52 VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g2_MXNA1_4 bB net52 VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI6_MXNOE ny A bB VPW N18_DNW L=1.8e-07 W=6e-07
mXI6_MXNOE_2 ny A bB VPW N18_DNW L=1.8e-07 W=6e-07
mXI6_MXNOE_3 ny A bB VPW N18_DNW L=1.8e-07 W=6e-07
mXI6_MXNOE_4 ny A bB VPW N18_DNW L=1.8e-07 W=6e-07
mXI5_MXNOE ny nA net52 VPW N18_DNW L=1.8e-07 W=6e-07
mXI5_MXNOE_2 ny nA net52 VPW N18_DNW L=1.8e-07 W=6e-07
mXI5_MXNOE_3 ny nA net52 VPW N18_DNW L=1.8e-07 W=6e-07
mXI5_MXNOE_4 ny nA net52 VPW N18_DNW L=1.8e-07 W=6e-07
mX_g1_MXNA1 nA A VSS VPW N18_DNW L=1.8e-07 W=3.8e-07
mX_g1_MXNA1_2 nA A VSS VPW N18_DNW L=1.8e-07 W=3.8e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
mX_g0_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g0_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g0_MXNA1_4 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g0_MXNA1_5 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g0_MXNA1_6 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g3_MXPA1 net52 B VDD VNW P18_DNW L=1.8e-07 W=1.24e-06
mX_g3_MXPA1_2 net52 B VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g3_MXPA1_3 net52 B VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g3_MXPA1_4 net52 B VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g3_MXPA1_5 net52 B VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
mX_g3_MXPA1_6 net52 B VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g2_MXPA1 bB net52 VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g2_MXPA1_2 bB net52 VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g2_MXPA1_3 bB net52 VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g2_MXPA1_4 bB net52 VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mXI6_MXPOEN ny nA bB VNW P18_DNW L=1.8e-07 W=1.17e-06
mXI6_MXPOEN_2 ny nA bB VNW P18_DNW L=1.8e-07 W=1.17e-06
mXI6_MXPOEN_3 ny nA bB VNW P18_DNW L=1.8e-07 W=1.17e-06
mXI6_MXPOEN_4 ny nA bB VNW P18_DNW L=1.8e-07 W=1.17e-06
mXI6_MXPOEN_5 ny nA bB VNW P18_DNW L=1.8e-07 W=1.17e-06
mXI5_MXPOEN ny A net52 VNW P18_DNW L=1.8e-07 W=1.17e-06
mXI5_MXPOEN_2 ny A net52 VNW P18_DNW L=1.8e-07 W=1.17e-06
mXI5_MXPOEN_3 ny A net52 VNW P18_DNW L=1.8e-07 W=1.17e-06
mXI5_MXPOEN_4 ny A net52 VNW P18_DNW L=1.8e-07 W=1.17e-06
mXI5_MXPOEN_5 ny A net52 VNW P18_DNW L=1.8e-07 W=1.17e-06
mX_g1_MXPA1 nA A VDD VNW P18_DNW L=1.8e-07 W=1.82e-06
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g0_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g0_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g0_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g0_MXPA1_5 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g0_MXPA1_6 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g0_MXPA1_7 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
.ends


.SUBCKT CLKXOR2_X2_A7TR Y VDD VNW VPW VSS A B
mX_g3_MXNA1 nB B VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
mX_g2_MXNA1 bB nB VSS VPW N18_DNW L=1.8e-07 W=3.3e-07
mXI6_MXNOE ny A bB VPW N18_DNW L=1.8e-07 W=3.3e-07
mXI5_MXNOE ny nA nB VPW N18_DNW L=1.8e-07 W=3.3e-07
mX_g1_MXNA1 nA A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g3_MXPA1 nB B VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
mX_g2_MXPA1 bB nB VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
mXI6_MXPOEN ny nA bB VNW P18_DNW L=1.8e-07 W=8.5e-07
mXI5_MXPOEN ny A nB VNW P18_DNW L=1.8e-07 W=8.5e-07
mX_g1_MXPA1 nA A VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT CLKXOR2_X4_A7TR Y VDD VNW VPW VSS A B
mX_g3_MXNA1 nB B VSS VPW N18_DNW L=1.8e-07 W=8.6e-07
mX_g2_MXNA1 bB nB VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g1_MXNA1 nA A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNOE ny A bB VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI5_MXNOE ny nA nB VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g0_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g3_MXPA1 nB B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g3_MXPA1_2 nB B VDD VNW P18_DNW L=1.8e-07 W=1.27e-06
mX_g2_MXPA1 bB nB VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
mX_g2_MXPA1_2 bB nB VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
mX_g1_MXPA1 nA A VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
mXI6_MXPOEN ny nA bB VNW P18_DNW L=1.8e-07 W=8.2e-07
mXI6_MXPOEN_2 ny nA bB VNW P18_DNW L=1.8e-07 W=8.2e-07
mXI5_MXPOEN ny A nB VNW P18_DNW L=1.8e-07 W=8.2e-07
mXI5_MXPOEN_2 ny A nB VNW P18_DNW L=1.8e-07 W=6.8e-07
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.52e-06
mX_g0_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT CLKXOR2_X8_A7TR Y VDD VNW VPW VSS A B
mX_g3_MXNA1 nB B VSS VPW N18_DNW L=1.8e-07 W=8.6e-07
mX_g3_MXNA1_2 nB B VSS VPW N18_DNW L=1.8e-07 W=8.6e-07
mX_g2_MXNA1 bB nB VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g2_MXNA1_2 bB nB VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g1_MXNA1 nA A VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI6_MXNOE ny A bB VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI6_MXNOE_2 ny A bB VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI5_MXNOE ny nA nB VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI5_MXNOE_2 ny nA nB VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g0_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g0_MXNA1_3 Y ny VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g3_MXPA1 nB B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g3_MXPA1_2 nB B VDD VNW P18_DNW L=1.8e-07 W=1.17e-06
mX_g3_MXPA1_3 nB B VDD VNW P18_DNW L=1.8e-07 W=1.17e-06
mX_g3_MXPA1_4 nB B VDD VNW P18_DNW L=1.8e-07 W=1.17e-06
mX_g2_MXPA1 bB nB VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g2_MXPA1_2 bB nB VDD VNW P18_DNW L=1.8e-07 W=1.55e-06
mX_g1_MXPA1 nA A VDD VNW P18_DNW L=1.8e-07 W=1.09e-06
mXI6_MXPOEN ny nA bB VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI6_MXPOEN_2 ny nA bB VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI6_MXPOEN_3 ny nA bB VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI5_MXPOEN ny A nB VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI5_MXPOEN_2 ny A nB VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI5_MXPOEN_3 ny A nB VNW P18_DNW L=1.8e-07 W=1.12e-06
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_3 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_4 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFHQN_X1_A7TR QN VDD VNW VPW VSS CK D
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
MXN2 net71 cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 m nmin net71 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI12_MXNOE m c XI12_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI12_MXNA1 XI12_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=3.8e-07
mXI43_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI11_MXNOE ns cn XI11_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXNA1 XI11_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 net48 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP1 net48 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP2 net54 c VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP3 m nmin net54 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI12_MXPOEN m cn XI12_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI12_MXPA1 XI12_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI43_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI11_MXPOEN ns c XI11_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXPA1 XI11_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends

.SUBCKT DFFHQN_X2_A7TR QN VDD VNW VPW VSS CK D
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
MXN2 net063 cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 m nmin net063 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI12_MXNOE m c XI12_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI12_MXNA1 XI12_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=3.8e-07
mXI43_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI11_MXNOE ns cn XI11_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXNA1 XI11_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=3.8e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 net051 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP1 net051 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP2 net050 c VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP3 m nmin net050 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI12_MXPOEN m cn XI12_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI12_MXPA1 XI12_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI43_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI11_MXPOEN ns c XI11_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXPA1 XI11_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=5.7e-07
.ends


.SUBCKT DFFHQN_X4_A7TR QN VDD VNW VPW VSS CK D
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN0 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 net063 cn VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN1 m nmin net063 VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI12_MXNOE m c XI12_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI12_MXNA1 XI12_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI43_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI11_MXNOE ns cn XI11_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXNA1 XI11_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1 net051 c cn VNW P18_DNW L=1.8e-07 W=7.5e-07
MXP0 net051 CK VDD VNW P18_DNW L=1.8e-07 W=7.5e-07
MXP2 net050 c VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
MXP3 m nmin net050 VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI12_MXPOEN m cn XI12_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI12_MXPA1 XI12_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI43_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=9.6e-07
mXI11_MXPOEN ns c XI11_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXPA1 XI11_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g9_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFHQN_X8_A7TR QN VDD VNW VPW VSS CK D
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=3e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=5.2e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN0 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.3e-07
MXN1 m nmin net063 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN2 net063 cn VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
mXI12_MXNOE m c XI12_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI12_MXNA1 XI12_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=5.2e-07
mX_g5_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=5.2e-07
mXI43_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=4.7e-07
mXI43_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=4.7e-07
mXI11_MXNOE ns cn XI11_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXNA1 XI11_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mX_g2_MXNA1_2 s ns VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXNA1_3 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXNA1_4 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1 net051 c cn VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP0 net051 CK VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP3 m nmin net050 VNW P18_DNW L=1.8e-07 W=1.22e-06
MXP2 net050 c VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
mXI12_MXPOEN m cn XI12_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI12_MXPA1 XI12_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g5_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI43_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI43_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI11_MXPOEN ns c XI11_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI11_MXPA1 XI11_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g2_MXPA1_2 s ns VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g9_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g9_MXPA1_3 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g9_MXPA1_4 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFHQ_X1_A7TR Q VDD VNW VPW VSS CK D
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
MXN3 net87 cn VSS VPW N18_DNW L=1.8e-07 W=5e-07
MXN1 m nmin net87 VPW N18_DNW L=1.8e-07 W=5e-07
mXI12_MXNOE m c XI12_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI12_MXNA1 XI12_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI36_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=5.5e-07
mXI11_MXNOE ns cn XI11_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXNA1 XI11_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
MXP0 net061 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP4 net061 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.04e-06
MXP2 net62 c VDD VNW P18_DNW L=1.8e-07 W=7.5e-07
MXP5 m nmin net62 VNW P18_DNW L=1.8e-07 W=7.5e-07
mXI12_MXPOEN m cn XI12_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI12_MXPA1 XI12_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI36_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.08e-06
mXI11_MXPOEN ns c XI11_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXPA1 XI11_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT DFFHQ_X2_A7TR Q VDD VNW VPW VSS CK D
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN0 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN1 m nmin net87 VPW N18_DNW L=1.8e-07 W=7e-07
MXN5 net87 cn VSS VPW N18_DNW L=1.8e-07 W=7e-07
mXI12_MXNA1 XI12_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI12_MXNOE m c XI12_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=8.9e-07
mXI36_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI11_MXNOE ns cn XI11_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXNA1 XI11_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 net061 CK VDD VNW P18_DNW L=1.8e-07 W=8.2e-07
MXP9 net061 c cn VNW P18_DNW L=1.8e-07 W=8.2e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP2 net62 c VDD VNW P18_DNW L=1.8e-07 W=1.05e-06
MXP8 m nmin net62 VNW P18_DNW L=1.8e-07 W=1.05e-06
mXI12_MXPOEN m cn XI12_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI12_MXPA1 XI12_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g5_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI36_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.22e-06
mXI11_MXPOEN ns c XI11_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXPA1 XI11_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFHQ_X4_A7TR Q VDD VNW VPW VSS CK D
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
MXN0 cn CK VSS VPW N18_DNW L=1.8e-07 W=4e-07
MXN7_2 net87__2 cn VSS VPW N18_DNW L=1.8e-07 W=4e-07
MXN1_2 m nmin net87__2 VPW N18_DNW L=1.8e-07 W=4e-07
MXN1 m nmin net87 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN7 net87 cn VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mXI12_MXNOE m c XI12_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI12_MXNA1 XI12_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mX_g5_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI36_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI36_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI11_MXNOE ns cn XI11_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXNA1 XI11_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.15e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=1.06e-06
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=5.9e-07
MXP10 net061 c cn VNW P18_DNW L=1.8e-07 W=1.18e-06
MXP0 net061 CK VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
MXP12_2 net62__2 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP11_2 m nmin net62__2 VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP11 m nmin net62 VNW P18_DNW L=1.8e-07 W=7.5e-07
MXP12 net62 c VDD VNW P18_DNW L=1.8e-07 W=7.5e-07
mXI12_MXPOEN m cn XI12_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI12_MXPA1 XI12_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g5_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI36_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.38e-06
mXI36_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.38e-06
mXI11_MXPOEN ns c XI11_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI11_MXPA1 XI11_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFHQ_X8_A7TR Q VDD VNW VPW VSS CK D
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
MXN1_2 m nmin net87__2 VPW N18_DNW L=1.8e-07 W=6.3e-07
MXN7_2 net87__2 cn VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
MXN7_3 net87__3 cn VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
MXN1_3 m nmin net87__3 VPW N18_DNW L=1.8e-07 W=6.3e-07
MXN1 m nmin net87 VPW N18_DNW L=1.8e-07 W=6.9e-07
MXN7 net87 cn VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI12_MXNOE m c XI12_n1 VPW N18_DNW L=1.8e-07 W=2.9e-07
mXI12_MXNA1 XI12_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=9.1e-07
mX_g5_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=9.1e-07
mX_g5_MXNA1_3 nm m VSS VPW N18_DNW L=1.8e-07 W=9.1e-07
MXN0 cn CK VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mX_g10_MXNA1_2 c nck VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI36_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8.7e-07
mXI36_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=8.6e-07
mXI36_MXNOE_3 ns c nm VPW N18_DNW L=1.8e-07 W=8.6e-07
mXI11_MXNOE ns cn XI11_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXNA1 XI11_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_3 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_4 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g13_MXPA1_2 nmin D VDD VNW P18_DNW L=1.8e-07 W=8.9e-07
MXP13_2 m nmin net62__2 VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP2_2 net62__2 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP2_3 net62__3 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP13_3 m nmin net62__3 VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP13 m nmin net62 VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP2 net62 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mXI12_MXPOEN m cn XI12_p1 VNW P18_DNW L=1.8e-07 W=4.3e-07
mXI12_MXPA1 XI12_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.3e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g5_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g5_MXPA1_3 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g5_MXPA1_4 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP0_2 net061__2 CK VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP14_2 net061__2 c cn VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP14 net061 c cn VNW P18_DNW L=1.8e-07 W=1.19e-06
MXP0 net061 CK VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=1.05e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI36_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI36_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI36_MXPOEN_3 ns cn nm VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI11_MXPOEN ns c XI11_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXPA1 XI11_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_3 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_4 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFH_X1_A7TR Q QN VDD VNW VPW VSS CK D
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
MXN3 net42 cn VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN1 m nmin net42 VPW N18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXNOE m c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI32_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI1_MXNOE ns cn XI1_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA1 XI1_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 net63 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP5 net63 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.08e-06
MXP2 net53 c VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
MXP6 m nmin net53 VNW P18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXPOEN m cn XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 XI0_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI32_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI1_MXPOEN ns c XI1_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXPA1 XI1_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT DFFH_X2_A7TR Q QN VDD VNW VPW VSS CK D
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN0 cn CK VSS VPW N18_DNW L=1.8e-07 W=3e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=4.7e-07
MXN1 m nmin net42 VPW N18_DNW L=1.8e-07 W=7.4e-07
MXN5 net42 cn VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI0_MXNA1 XI0_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNOE m c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=9.2e-07
mXI32_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8.3e-07
mXI1_MXNOE ns cn XI1_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA1 XI1_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 net63 CK VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
MXP12 net63 c cn VNW P18_DNW L=1.8e-07 W=8.5e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
MXP8 net53 c VDD VNW P18_DNW L=1.8e-07 W=1.11e-06
MXP11 m nmin net53 VNW P18_DNW L=1.8e-07 W=1.11e-06
mXI0_MXPOEN m cn XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 XI0_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=8.3e-07
mX_g5_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=8.3e-07
mXI32_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.22e-06
mXI1_MXPOEN ns c XI1_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXPA1 XI1_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFH_X4_A7TR Q QN VDD VNW VPW VSS CK D
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=4.6e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
MXN0 cn CK VSS VPW N18_DNW L=1.8e-07 W=4e-07
MXN6_2 net42__2 cn VSS VPW N18_DNW L=1.8e-07 W=4e-07
MXN1_2 m nmin net42__2 VPW N18_DNW L=1.8e-07 W=4e-07
MXN1 m nmin net42 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN6 net42 cn VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNOE m c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=7.8e-07
mX_g5_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI32_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8e-07
mXI32_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI1_MXNOE ns cn XI1_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA1 XI1_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=6.1e-07
MXP14 net63 c cn VNW P18_DNW L=1.8e-07 W=1.18e-06
MXP0 net63 CK VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
MXP8_2 net53__2 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP13_2 m nmin net53__2 VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP13 m nmin net53 VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP8 net53 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mXI0_MXPOEN m cn XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 XI0_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g5_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI32_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI32_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI1_MXPOEN ns c XI1_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 XI1_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFH_X8_A7TR Q QN VDD VNW VPW VSS CK D
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN1_2 m nmin net42__2 VPW N18_DNW L=1.8e-07 W=6.3e-07
MXN6_2 net42__2 cn VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
MXN6_3 net42__3 cn VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
MXN1_3 m nmin net42__3 VPW N18_DNW L=1.8e-07 W=6.3e-07
MXN1 m nmin net42 VPW N18_DNW L=1.8e-07 W=6.9e-07
MXN6 net42 cn VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI0_MXNOE m c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.9e-07
mXI0_MXNA1 XI0_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=9.1e-07
mX_g5_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=9.1e-07
mX_g5_MXNA1_3 nm m VSS VPW N18_DNW L=1.8e-07 W=9.1e-07
MXN0 cn CK VSS VPW N18_DNW L=1.8e-07 W=8.3e-07
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mX_g10_MXNA1_2 c nck VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI32_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8.7e-07
mXI32_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=8.6e-07
mXI32_MXNOE_3 ns c nm VPW N18_DNW L=1.8e-07 W=8.6e-07
mXI1_MXNOE ns cn XI1_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXNA1 XI1_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_3 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_4 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
MXP12_2 m nmin net53__2 VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP13_2 net53__2 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP13_3 net53__3 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP12_3 m nmin net53__3 VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP12 m nmin net53 VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP13 net53 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mXI0_MXPOEN m cn XI0_p1 VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA1 XI0_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g5_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g5_MXPA1_3 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g5_MXPA1_4 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP0_2 net63__2 CK VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP14_2 net63__2 c cn VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP14 net63 c cn VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP0 net63 CK VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=1.06e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI32_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI32_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI32_MXPOEN_3 ns cn nm VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI1_MXPOEN ns c XI1_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI1_MXPA1 XI1_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_3 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_4 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFNH_X1_A7TR Q QN VDD VNW VPW VSS CKN D
mX_g13_MXNA1 net150 D VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN0 c CKN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 nckn CKN VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 cn nckn VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN2 net67 cn VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
MXN1 m net150 net67 VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI10_MXNOE m c XI10_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI10_MXNA1 XI10_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI37_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI11_MXNOE ns cn XI11_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI11_MXNA1 XI11_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI54_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI52_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g13_MXPA1 net150 D VDD VNW P18_DNW L=1.8e-07 W=6e-07
MXP0 net56 CKN VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP1 net56 cn c VNW P18_DNW L=1.8e-07 W=8e-07
mX_g14_MXPA1 nckn CKN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 cn nckn VDD VNW P18_DNW L=1.8e-07 W=8e-07
mX_g10_MXPA1_2 cn nckn VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net42 c VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
MXP3 m net150 net42 VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI10_MXPOEN m cn XI10_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI10_MXPA1 XI10_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=8.9e-07
mXI37_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=8.9e-07
mXI11_MXPOEN ns c XI11_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXPA1 XI11_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI54_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI52_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
.ends


.SUBCKT DFFNH_X2_A7TR Q QN VDD VNW VPW VSS CKN D
mX_g13_MXNA1 net150 D VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
MXN0 c CKN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 nckn CKN VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
mX_g10_MXNA1 cn nckn VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
MXN3 net67 cn VSS VPW N18_DNW L=1.8e-07 W=1e-06
MXN1 m net150 net67 VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI10_MXNOE m c XI10_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI10_MXNA1 XI10_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI37_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8.3e-07
mXI11_MXNOE ns cn XI11_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXNA1 XI11_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI54_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI52_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g13_MXPA1 net150 D VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP0 net56 CKN VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP1 net56 cn c VNW P18_DNW L=1.8e-07 W=8e-07
mX_g14_MXPA1 nckn CKN VDD VNW P18_DNW L=1.8e-07 W=4.3e-07
mX_g10_MXPA1 cn nckn VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g10_MXPA1_2 cn nckn VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net42 c VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
MXP5 m net150 net42 VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI10_MXPOEN m cn XI10_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI10_MXPA1 XI10_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.24e-06
mXI37_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI11_MXPOEN ns c XI11_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXPA1 XI11_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI54_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI52_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
.ends

.SUBCKT DFFNH_X4_A7TR Q QN VDD VNW VPW VSS CKN D
mX_g13_MXNA1 net150 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN0 c CKN VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g14_MXNA1 nckn CKN VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mX_g10_MXNA1 cn nckn VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
MXN4_2 net67__2 cn VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN1_2 m net150 net67__2 VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN1 m net150 net67 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN4 net67 cn VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI10_MXNOE m c XI10_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI10_MXNA1 XI10_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=7.8e-07
mX_g5_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=7.8e-07
mXI37_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8e-07
mXI37_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI11_MXNOE ns cn XI11_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXNA1 XI11_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI54_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI52_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI52_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g13_MXPA1 net150 D VDD VNW P18_DNW L=1.8e-07 W=1.27e-06
MXP0 net56 CKN VDD VNW P18_DNW L=1.8e-07 W=1e-06
MXP8 net56 cn c VNW P18_DNW L=1.8e-07 W=1e-06
mX_g14_MXPA1 nckn CKN VDD VNW P18_DNW L=1.8e-07 W=6.4e-07
mX_g10_MXPA1 cn nckn VDD VNW P18_DNW L=1.8e-07 W=1e-06
mX_g10_MXPA1_2 cn nckn VDD VNW P18_DNW L=1.8e-07 W=1e-06
MXP2_2 net42__2 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP7_2 m net150 net42__2 VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP7 m net150 net42 VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP2 net42 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mXI10_MXPOEN m cn XI10_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI10_MXPA1 XI10_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.09e-06
mX_g5_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=1.09e-06
mXI37_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.09e-06
mXI37_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.09e-06
mXI11_MXPOEN ns c XI11_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI11_MXPA1 XI11_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI54_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI52_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI52_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFNH_X8_A7TR Q QN VDD VNW VPW VSS CKN D
mX_g13_MXNA1 net150 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g13_MXNA1_2 net150 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN0 c CKN VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mX_g14_MXNA1 nckn CKN VSS VPW N18_DNW L=1.8e-07 W=8.7e-07
mX_g10_MXNA1 cn nckn VSS VPW N18_DNW L=1.8e-07 W=7e-07
mX_g10_MXNA1_2 cn nckn VSS VPW N18_DNW L=1.8e-07 W=7e-07
MXN1_2 m net150 net67__2 VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN4_2 net67__2 cn VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN4_3 net67__3 cn VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
MXN1_3 m net150 net67__3 VPW N18_DNW L=1.8e-07 W=7.6e-07
MXN1 m net150 net67 VPW N18_DNW L=1.8e-07 W=7.9e-07
MXN4 net67 cn VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mXI10_MXNOE m c XI10_n1 VPW N18_DNW L=1.8e-07 W=4e-07
mXI10_MXNA1 XI10_n1 nm VSS VPW N18_DNW L=1.8e-07 W=4e-07
mX_g5_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g5_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g5_MXNA1_3 nm m VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI37_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI37_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI37_MXNOE_3 ns c nm VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI11_MXNOE ns cn XI11_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXNA1 XI11_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI54_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI52_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI52_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI52_MXNA1_3 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI52_MXNA1_4 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g13_MXPA1 net150 D VDD VNW P18_DNW L=1.8e-07 W=1.31e-06
mX_g13_MXPA1_2 net150 D VDD VNW P18_DNW L=1.8e-07 W=1.31e-06
MXP0_2 net56__2 CKN VDD VNW P18_DNW L=1.8e-07 W=8.8e-07
MXP9_2 net56__2 cn c VNW P18_DNW L=1.8e-07 W=8.8e-07
MXP9 net56 cn c VNW P18_DNW L=1.8e-07 W=8.8e-07
MXP0 net56 CKN VDD VNW P18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 nckn CKN VDD VNW P18_DNW L=1.8e-07 W=1.14e-06
mX_g10_MXPA1 cn nckn VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g10_MXPA1_2 cn nckn VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP8_2 m net150 net42__2 VNW P18_DNW L=1.8e-07 W=1.22e-06
MXP2_2 net42__2 c VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
MXP2_3 net42__3 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP8_3 m net150 net42__3 VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP8 m net150 net42 VNW P18_DNW L=1.8e-07 W=7.6e-07
MXP2 net42 c VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mXI10_MXPOEN m cn XI10_p1 VNW P18_DNW L=1.8e-07 W=6e-07
mXI10_MXPA1 XI10_p1 nm VDD VNW P18_DNW L=1.8e-07 W=6e-07
mX_g5_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mX_g5_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g5_MXPA1_3 nm m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI37_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI37_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI37_MXPOEN_3 ns cn nm VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI11_MXPOEN ns c XI11_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI11_MXPA1 XI11_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI54_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI52_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI52_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI52_MXPA1_3 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI52_MXPA1_4 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFNSRH_X1_A7TR Q QN VDD VNW VPW VSS CKN D RN SN
mX_g14_MXNA1 nck CKN VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN2 c CKN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 cn nck VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=4e-07
mX_g5_MXNA1 nmset SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN12 VSS SN net68 VPW N18_DNW L=1.8e-07 W=7.3e-07
MXN11 net68 cn net72 VPW N18_DNW L=1.8e-07 W=7.3e-07
MXN0 m nmin net72 VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI19_MXNOE m c XI19_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI19_MXNA1 XI19_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 nm m net80 VPW N18_DNW L=1.8e-07 W=6.9e-07
MXN13 VSS RN net80 VPW N18_DNW L=1.8e-07 W=6.9e-07
MXN6 nm nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI58_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=5.9e-07
MXN7 ns cn net91 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN14 net91 RN net88 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN15 VSS s net88 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 ns nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g11_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g14_MXPA1 nck CKN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net152 CKN VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP13 net152 cn c VNW P18_DNW L=1.8e-07 W=8e-07
mX_g10_MXPA1 cn nck VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=6e-07
mX_g5_MXPA1 nmset SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP12 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP14 m nmin net118 VNW P18_DNW L=1.8e-07 W=6.8e-07
MXP9 net118 c VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI19_MXPOEN m cn XI19_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI19_MXPA1 XI19_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP11 nm m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
MXP1 net142 nmset VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP15 nm RN net142 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI58_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=6.9e-07
MXP16 ns nmset net154 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 net154 RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP18 ns c net110 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP17 net110 nmset net114 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 VDD s net114 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g11_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT DFFNSRH_X2_A7TR Q QN VDD VNW VPW VSS CKN D RN SN
mX_g14_MXNA1 nck CKN VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
MXN2 c CKN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 cn nck VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=5.5e-07
mX_g5_MXNA1 nmset SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN17 VSS SN net70 VPW N18_DNW L=1.8e-07 W=9.2e-07
MXN16 net70 cn net66 VPW N18_DNW L=1.8e-07 W=9.2e-07
MXN0 m nmin net66 VPW N18_DNW L=1.8e-07 W=9.2e-07
mXI19_MXNOE m c XI19_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI19_MXNA1 XI19_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 nm m net78 VPW N18_DNW L=1.8e-07 W=9.3e-07
MXN18 VSS RN net78 VPW N18_DNW L=1.8e-07 W=9.3e-07
MXN6 nm nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI58_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=7e-07
MXN7 ns cn net89 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN14 net89 RN net86 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN15 VSS s net86 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 ns nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g11_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 nck CKN VDD VNW P18_DNW L=1.8e-07 W=4.3e-07
MXP2 net154 CKN VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP13 net154 cn c VNW P18_DNW L=1.8e-07 W=8e-07
mX_g10_MXPA1 cn nck VDD VNW P18_DNW L=1.8e-07 W=1.38e-06
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=8.3e-07
mX_g5_MXPA1 nmset SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP12 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP19 m nmin net120 VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP9 net120 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mXI19_MXPOEN m cn XI19_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI19_MXPA1 XI19_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP11 nm m VDD VNW P18_DNW L=1.8e-07 W=6.2e-07
MXP11_2 nm m VDD VNW P18_DNW L=1.8e-07 W=6.2e-07
MXP1 net144 nmset VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP15 nm RN net144 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI58_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=9.8e-07
MXP20 ns nmset net104 VNW P18_DNW L=1.8e-07 W=4.7e-07
MXP4 net104 RN VDD VNW P18_DNW L=1.8e-07 W=4.7e-07
MXP18 ns c net112 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP17 net112 nmset net116 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 VDD s net116 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g11_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFNSRH_X4_A7TR Q QN VDD VNW VPW VSS CKN D RN SN
mX_g14_MXNA1 nck CKN VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
MXN2 c CKN VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g10_MXNA1 cn nck VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=9.2e-07
mX_g5_MXNA1 nmset SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN20_2 VSS SN net67__2 VPW N18_DNW L=1.8e-07 W=8.6e-07
MXN19_2 net67__2 cn net71__2 VPW N18_DNW L=1.8e-07 W=6.6e-07
MXN0_2 m nmin net71__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MXN0 m nmin net71 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN19 net67 cn net71 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN20 VSS SN net67 VPW N18_DNW L=1.8e-07 W=8.4e-07
mXI19_MXNOE m c XI19_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI19_MXNA1 XI19_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN22_2 VSS RN net79__2 VPW N18_DNW L=1.8e-07 W=7.8e-07
MXN4_2 nm m net79__2 VPW N18_DNW L=1.8e-07 W=7.8e-07
MXN4 nm m net79 VPW N18_DNW L=1.8e-07 W=7.8e-07
MXN22 VSS RN net79 VPW N18_DNW L=1.8e-07 W=7.8e-07
MXN6 nm nmset VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mXI58_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN7 ns cn net90 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN14 net90 RN net87 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN15 VSS s net87 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 ns nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g11_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 nck CKN VDD VNW P18_DNW L=1.8e-07 W=6.4e-07
MXP2 net155 CKN VDD VNW P18_DNW L=1.8e-07 W=1e-06
MXP21 net155 cn c VNW P18_DNW L=1.8e-07 W=1e-06
mX_g10_MXPA1 cn nck VDD VNW P18_DNW L=1.8e-07 W=1.11e-06
mX_g10_MXPA1_2 cn nck VDD VNW P18_DNW L=1.8e-07 W=1.11e-06
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.27e-06
mX_g5_MXPA1 nmset SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP12 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9_2 net121__2 c VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP24_2 m nmin net121__2 VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP24 m nmin net121 VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP9 net121 c VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
mXI19_MXPA1 XI19_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI19_MXPOEN m cn XI19_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP11 nm m VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP11_2 nm m VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP1 net145 nmset VDD VNW P18_DNW L=1.8e-07 W=5.5e-07
MXP15 nm RN net145 VNW P18_DNW L=1.8e-07 W=5.5e-07
mXI58_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=4.1e-07
mXI58_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.2e-06
MXP4 net105 RN VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP23 ns nmset net105 VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP18 ns c net113 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP17 net113 nmset net117 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 VDD s net117 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g11_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFNSRH_X8_A7TR Q QN VDD VNW VPW VSS CKN D RN SN
mX_g14_MXNA1 nck CKN VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
MXN2 c CKN VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g10_MXNA1 cn nck VSS VPW N18_DNW L=1.8e-07 W=7.9e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=9.2e-07
mX_g5_MXNA1 nmset SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN20_2 VSS SN net66__2 VPW N18_DNW L=1.8e-07 W=8.6e-07
MXN19_2 net66__2 cn net70__2 VPW N18_DNW L=1.8e-07 W=6.6e-07
MXN25_2 m nmin net70__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MXN25 m nmin net70 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN19 net66 cn net70 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN20 VSS SN net66 VPW N18_DNW L=1.8e-07 W=8.4e-07
mXI19_MXNOE m c XI19_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI19_MXNA1 XI19_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN23_2 VSS RN net78__2 VPW N18_DNW L=1.8e-07 W=7.8e-07
MXN4_2 nm m net78__2 VPW N18_DNW L=1.8e-07 W=7.8e-07
MXN4 nm m net78 VPW N18_DNW L=1.8e-07 W=7.8e-07
MXN23 VSS RN net78 VPW N18_DNW L=1.8e-07 W=7.8e-07
MXN6 nm nmset VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mXI58_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN7 ns cn net89 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN14 net89 RN net86 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN15 VSS s net86 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 ns nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g11_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_3 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_4 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 nck CKN VDD VNW P18_DNW L=1.8e-07 W=6.4e-07
MXP2 net154 CKN VDD VNW P18_DNW L=1.8e-07 W=1e-06
MXP24 net154 cn c VNW P18_DNW L=1.8e-07 W=1e-06
mX_g10_MXPA1 cn nck VDD VNW P18_DNW L=1.8e-07 W=1.11e-06
mX_g10_MXPA1_2 cn nck VDD VNW P18_DNW L=1.8e-07 W=1.11e-06
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.27e-06
mX_g5_MXPA1 nmset SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP12 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9_2 net120__2 c VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP26_2 m nmin net120__2 VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP26 m nmin net120 VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP9 net120 c VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
mXI19_MXPA1 XI19_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI19_MXPOEN m cn XI19_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP11 nm m VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP11_2 nm m VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP1 net144 nmset VDD VNW P18_DNW L=1.8e-07 W=5.5e-07
MXP15 nm RN net144 VNW P18_DNW L=1.8e-07 W=5.5e-07
mXI58_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=4.1e-07
mXI58_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.2e-06
MXP4 net104 RN VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP25 ns nmset net104 VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP18 ns c net112 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP17 net112 nmset net116 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 VDD s net116 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g11_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_3 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_4 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFQN_X1_A7TR QN VDD VNW VPW VSS CK D
mXI4_MXNA1 XI4_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNOE nm cn XI4_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNOE nm c XI5_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1 XI5_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNA1 XI6_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNOE ns c XI6_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNOE ns cn XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNA1 XI7_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXPA1 XI4_p1 D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXPOEN nm c XI4_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI5_MXPOEN nm cn XI5_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI5_MXPA1 XI5_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI6_MXPA1 XI6_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI6_MXPOEN ns cn XI6_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPOEN ns c XI7_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXPA1 XI7_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT DFFQN_X2_A7TR QN VDD VNW VPW VSS CK D
mXI4_MXNA1 XI4_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNOE nm cn XI4_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNOE nm c XI5_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1 XI5_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNA1 XI6_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNOE ns c XI6_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNOE ns cn XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNA1 XI7_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXPA1 XI4_p1 D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXPOEN nm c XI4_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI5_MXPOEN nm cn XI5_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI5_MXPA1 XI5_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI6_MXPA1 XI6_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI6_MXPOEN ns cn XI6_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPOEN ns c XI7_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXPA1 XI7_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.27e-06
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT DFFQN_X4_A7TR QN VDD VNW VPW VSS CK D
mXI4_MXNA1 XI4_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNOE nm cn XI4_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNOE nm c XI5_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1 XI5_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNA1 XI6_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNOE ns c XI6_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI7_MXNOE ns cn XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNA1 XI7_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI4_MXPA1 XI4_p1 D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXPOEN nm c XI4_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI5_MXPOEN nm cn XI5_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI5_MXPA1 XI5_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI6_MXPA1 XI6_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI6_MXPOEN ns cn XI6_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXPOEN ns c XI7_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXPA1 XI7_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFQ_X1_A7TR Q VDD VNW VPW VSS CK D
mXI4_MXNA1 XI4_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNOE nm cn XI4_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNOE nm c XI5_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1 XI5_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNA1 XI6_n1 m VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI6_MXNOE ns c XI6_n1 VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI7_MXNOE ns cn XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNA1 XI7_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI4_MXPA1 XI4_p1 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI4_MXPOEN nm c XI4_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI5_MXPOEN nm cn XI5_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI5_MXPA1 XI5_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI6_MXPA1 XI6_p1 m VDD VNW P18_DNW L=1.8e-07 W=6.2e-07
mXI6_MXPOEN ns cn XI6_p1 VNW P18_DNW L=1.8e-07 W=6.2e-07
mXI7_MXPOEN ns c XI7_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXPA1 XI7_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT DFFQ_X2_A7TR Q VDD VNW VPW VSS CK D
mXI4_MXNA1 XI4_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNOE nm cn XI4_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNOE nm c XI5_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1 XI5_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNA1 XI6_n1 m VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI6_MXNOE ns c XI6_n1 VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI7_MXNOE ns cn XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNA1 XI7_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI4_MXPA1 XI4_p1 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI4_MXPOEN nm c XI4_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI5_MXPOEN nm cn XI5_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI5_MXPA1 XI5_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI6_MXPA1 XI6_p1 m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI6_MXPOEN ns cn XI6_p1 VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI7_MXPOEN ns c XI7_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXPA1 XI7_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFQ_X4_A7TR Q VDD VNW VPW VSS CK D
mXI4_MXNA1 XI4_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNOE nm cn XI4_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNOE nm c XI5_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1 XI5_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=3.2e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNA1 XI6_n1 m VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI6_MXNOE ns c XI6_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI7_MXNOE ns cn XI7_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXNA1 XI7_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI4_MXPA1 XI4_p1 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI4_MXPOEN nm c XI4_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI5_MXPOEN nm cn XI5_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI5_MXPA1 XI5_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
mX_g14_MXPA1_2 cn CK VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI6_MXPA1 XI6_p1 m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI6_MXPOEN ns cn XI6_p1 VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI7_MXPOEN ns c XI7_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI7_MXPA1 XI7_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends

.SUBCKT DFFRHQ_X1_A7TR Q VDD VNW VPW VSS CK D RN
mXI49_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI47_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI48_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
MXN10 net90 cn VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN2 m nmin net90 VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN3 m c net67 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN12 VSS nm net67 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN11 nm m net74 VPW N18_DNW L=1.8e-07 W=7.1e-07
MXN6 net74 RN VSS VPW N18_DNW L=1.8e-07 W=7.1e-07
mXI58_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=5.2e-07
MXN7 ns cn net86 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN13 net86 RN net83 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN14 VSS s net83 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI50_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI51_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI49_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
MXP0 net127 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP11 net127 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mXI47_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI48_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.03e-06
MXP2 net101 c VDD VNW P18_DNW L=1.8e-07 W=7.5e-07
MXP12 m nmin net101 VNW P18_DNW L=1.8e-07 W=7.5e-07
MXP14 m cn net105 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 VDD nm net105 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 nm m VDD VNW P18_DNW L=1.8e-07 W=1.01e-06
MXP7 nm RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI58_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.04e-06
MXP16 ns c net121 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP15 VDD s net121 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP17 VDD RN ns VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI50_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI51_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT DFFRHQ_X2_A7TR Q VDD VNW VPW VSS CK D RN
mXI49_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI47_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI48_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN15 net90 cn VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
MXN2 m nmin net90 VPW N18_DNW L=1.8e-07 W=6.1e-07
MXN3 m c net67 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN12 VSS nm net67 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN17_2 net74__2 RN VSS VPW N18_DNW L=1.8e-07 W=4.9e-07
MXN11_2 nm m net74__2 VPW N18_DNW L=1.8e-07 W=4.9e-07
MXN11 nm m net74 VPW N18_DNW L=1.8e-07 W=4.9e-07
MXN17 net74 RN VSS VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI58_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN7 ns cn net86 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN13 net86 RN net83 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN14 VSS s net83 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI50_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI51_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI49_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
MXP0 net131 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP18 net131 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mXI47_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI48_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
MXP2 net105 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP19 m nmin net105 VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP20 m cn net109 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 VDD nm net109 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 nm m VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP6_2 nm m VDD VNW P18_DNW L=1.8e-07 W=7.1e-07
MXP7 nm RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI58_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=7.7e-07
mXI58_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=7.4e-07
MXP21 ns c net125 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP15 VDD s net125 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP17 VDD RN ns VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI50_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI51_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFRHQ_X4_A7TR Q VDD VNW VPW VSS CK D RN
mXI49_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=4.6e-07
mXI48_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI47_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
MXN1 cn CK VSS VPW N18_DNW L=1.8e-07 W=4.6e-07
MXN18_2 net90__2 cn VSS VPW N18_DNW L=1.8e-07 W=4e-07
MXN2_2 m nmin net90__2 VPW N18_DNW L=1.8e-07 W=4e-07
MXN2 m nmin net90 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN18 net90 cn VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN3 m c net67 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN12 VSS nm net67 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN19_2 net74__2 RN VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
MXN11_2 nm m net74__2 VPW N18_DNW L=1.8e-07 W=7.4e-07
MXN11 nm m net74 VPW N18_DNW L=1.8e-07 W=7.4e-07
MXN19 net74 RN VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI58_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=5.2e-07
mXI58_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=5.3e-07
MXN7 ns cn net86 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN13 net86 RN net83 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN14 VSS s net83 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI50_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI51_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
mXI51_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI49_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI48_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI48_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=1.07e-06
mXI47_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=5.9e-07
MXP18 net131 c cn VNW P18_DNW L=1.8e-07 W=1.18e-06
MXP0 net131 CK VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
MXP22_2 net105__2 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP19_2 m nmin net105__2 VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP19 m nmin net105 VNW P18_DNW L=1.8e-07 W=7.5e-07
MXP22 net105 c VDD VNW P18_DNW L=1.8e-07 W=7.5e-07
MXP20 m cn net109 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 VDD nm net109 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 nm m VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
MXP6_2 nm m VDD VNW P18_DNW L=1.8e-07 W=1.21e-06
MXP7 nm RN VDD VNW P18_DNW L=1.8e-07 W=6.9e-07
mXI58_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.05e-06
mXI58_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.05e-06
MXP21 ns c net125 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP15 VDD s net125 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP17 VDD RN ns VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI50_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI51_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI51_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFRHQ_X8_A7TR Q VDD VNW VPW VSS CK D RN
mXI49_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI49_MXNA1_2 nmin D VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI48_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI48_MXNA1_2 c nck VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI47_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN1 cn CK VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN2_2 m nmin net90__2 VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN18_2 net90__2 cn VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN18_3 net90__3 cn VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN2_3 m nmin net90__3 VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN2 m nmin net90 VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN18 net90 cn VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN3 m c net67 VPW N18_DNW L=1.8e-07 W=3e-07
MXN12 VSS nm net67 VPW N18_DNW L=1.8e-07 W=3e-07
MXN11_2 nm m net74__2 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN19_2 net74__2 RN VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN19_3 net74__3 RN VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN11_3 nm m net74__3 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN11 nm m net74 VPW N18_DNW L=1.8e-07 W=7.3e-07
MXN19 net74 RN VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI58_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI58_MXNOE_2 ns c nm VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI58_MXNOE_3 ns c nm VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI58_MXNOE_4 ns c nm VPW N18_DNW L=1.8e-07 W=4.9e-07
MXN7 ns cn net86 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN13 net86 RN net83 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN14 VSS s net83 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI50_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI51_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI51_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI51_MXNA1_3 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI51_MXNA1_4 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI49_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI49_MXPA1_2 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI48_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI48_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI47_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=1.06e-06
MXP0_2 net131__2 CK VDD VNW P18_DNW L=1.8e-07 W=1.17e-06
MXP22_2 net131__2 c cn VNW P18_DNW L=1.8e-07 W=1.17e-06
MXP22 net131 c cn VNW P18_DNW L=1.8e-07 W=1.17e-06
MXP0 net131 CK VDD VNW P18_DNW L=1.8e-07 W=1.17e-06
MXP19_2 m nmin net105__2 VNW P18_DNW L=1.8e-07 W=1.22e-06
MXP23_2 net105__2 c VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
MXP23_3 net105__3 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP19_3 m nmin net105__3 VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP19 m nmin net105 VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP23 net105 c VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP20 m cn net109 VNW P18_DNW L=1.8e-07 W=4.5e-07
MXP5 VDD nm net109 VNW P18_DNW L=1.8e-07 W=4.5e-07
MXP6 nm m VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
MXP6_2 nm m VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
MXP6_3 nm m VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
MXP6_4 nm m VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
MXP7 nm RN VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI58_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI58_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.27e-06
mXI58_MXPOEN_3 ns cn nm VNW P18_DNW L=1.8e-07 W=1.08e-06
mXI58_MXPOEN_4 ns cn nm VNW P18_DNW L=1.8e-07 W=1.08e-06
MXP21 ns c net125 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP15 VDD s net125 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP17 VDD RN ns VNW P18_DNW L=1.8e-07 W=6.6e-07
MXP17_2 VDD RN ns VNW P18_DNW L=1.8e-07 W=6.6e-07
mXI50_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI51_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI51_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI51_MXPA1_3 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI51_MXPA1_4 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFRQ_X1_A7TR Q VDD VNW VPW VSS CK D RN
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.1e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net86 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 net78 D net86 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 nm cn net78 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 nm c net71 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net66 m net71 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 net66 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g4_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI37_MXNOE s c m VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNOE s cn XI4_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNA1 XI4_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 XI0_n1 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 ns s XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=4.6e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 nm RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net105 D VDD VNW P18_DNW L=1.8e-07 W=6e-07
MXP6 nm c net105 VNW P18_DNW L=1.8e-07 W=6e-07
MXP8 nm cn net89 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP7 VDD m net89 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g4_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI37_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXPOEN s c XI4_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXPA1 XI4_p1 ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA2 ns RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT DFFRQ_X2_A7TR Q VDD VNW VPW VSS CK D RN
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.1e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net86 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 net78 D net86 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 nm cn net78 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 nm c net71 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net66 m net71 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 net66 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g4_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI37_MXNOE s c m VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNOE s cn XI4_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNA1 XI4_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 XI0_n1 RN VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI0_MXNA1 ns s XI0_n1 VPW N18_DNW L=1.8e-07 W=3.7e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=4.6e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 nm RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net105 D VDD VNW P18_DNW L=1.8e-07 W=6e-07
MXP6 nm c net105 VNW P18_DNW L=1.8e-07 W=6e-07
MXP8 nm cn net89 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP7 VDD m net89 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g4_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI37_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXPOEN s c XI4_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXPA1 XI4_p1 ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA2 ns RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFRQ_X4_A7TR Q VDD VNW VPW VSS CK D RN
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.1e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 net86 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 net78 D net86 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 nm cn net78 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 nm c net71 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net66 m net71 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 net66 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g4_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI37_MXNOE s c m VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNOE s cn XI4_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNA1 XI4_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA2 XI0_n1 RN VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI0_MXNA1 ns s XI0_n1 VPW N18_DNW L=1.8e-07 W=6.7e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=4.6e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 nm RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net105 D VDD VNW P18_DNW L=1.8e-07 W=6e-07
MXP6 nm c net105 VNW P18_DNW L=1.8e-07 W=6e-07
MXP8 nm cn net89 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP7 VDD m net89 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g4_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI37_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXPOEN s c XI4_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXPA1 XI4_p1 ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA2 ns RN VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI0_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFR_X1_A7TR Q QN VDD VNW VPW VSS CK D RN
mXI41_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI42_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 net53 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 net45 D net53 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 nm cn net45 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 nm c net58 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net61 m net58 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net61 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI43_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI40_MXNOE s c m VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNOE s cn XI5_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1 XI5_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 XI1_n1 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 ns s XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI46_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI45_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI41_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI42_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
MXP1 nm RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net68 D VDD VNW P18_DNW L=1.8e-07 W=6e-07
MXP5 nm c net68 VNW P18_DNW L=1.8e-07 W=6e-07
MXP7 nm cn net72 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 VDD m net72 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI43_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI40_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=5.3e-07
mXI5_MXPOEN s c XI5_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI5_MXPA1 XI5_p1 ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2 ns RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI46_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI45_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT DFFR_X2_A7TR Q QN VDD VNW VPW VSS CK D RN
mXI41_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI42_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 net53 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 net45 D net53 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 nm cn net45 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 nm c net58 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net61 m net58 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net61 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI43_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI40_MXNOE s c m VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNOE s cn XI5_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1 XI5_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 XI1_n1 RN VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI1_MXNA1 ns s XI1_n1 VPW N18_DNW L=1.8e-07 W=3.7e-07
mXI46_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI45_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI41_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI42_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
MXP1 nm RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net68 D VDD VNW P18_DNW L=1.8e-07 W=6e-07
MXP5 nm c net68 VNW P18_DNW L=1.8e-07 W=6e-07
MXP8 nm cn net72 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 VDD m net72 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI43_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI40_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=5.3e-07
mXI5_MXPOEN s c XI5_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI5_MXPA1 XI5_p1 ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2 ns RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI46_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI45_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFR_X4_A7TR Q QN VDD VNW VPW VSS CK D RN
mXI41_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI42_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 net53 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 net45 D net53 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 nm cn net45 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 nm c net58 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net61 m net58 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 net61 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI43_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI40_MXNOE s c m VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNOE s cn XI5_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1 XI5_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 XI1_n1 RN VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI1_MXNA1 ns s XI1_n1 VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI46_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI46_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI45_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI45_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI41_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI42_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
MXP1 nm RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net68 D VDD VNW P18_DNW L=1.8e-07 W=6e-07
MXP5 nm c net68 VNW P18_DNW L=1.8e-07 W=6e-07
MXP8 nm cn net72 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 VDD m net72 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI43_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI40_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=5.3e-07
mXI5_MXPOEN s c XI5_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI5_MXPA1 XI5_p1 ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2 ns RN VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI46_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI46_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI45_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI45_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFSHQ_X1_A7TR Q VDD VNW VPW VSS CK D SN
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nmset_ SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 VSS SN net92 VPW N18_DNW L=1.8e-07 W=6.7e-07
MXN7 net92 cn net89 VPW N18_DNW L=1.8e-07 W=6.7e-07
MXN3 m nmin net89 VPW N18_DNW L=1.8e-07 W=6.7e-07
mXI6_MXNOE m c XI6_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNA1 XI6_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=6.5e-07
mXI54_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=5.5e-07
MXN9 ns cn net101 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 VSS s net101 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 ns nmset_ VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net099 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP7 net099 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.01e-06
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nmset_ SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 m nmin net091 VNW P18_DNW L=1.8e-07 W=6.8e-07
MXP1 net091 c VDD VNW P18_DNW L=1.8e-07 W=6.8e-07
mXI6_MXPA1 XI6_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI6_MXPOEN m cn XI6_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=5.5e-07
mX_g7_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=5.5e-07
mXI54_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.1e-06
MXP12 ns c net73 VNW P18_DNW L=1.8e-07 W=2.2e-07
MXP11 net73 nmset_ net76 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP10 VDD s net76 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT DFFSHQ_X2_A7TR Q VDD VNW VPW VSS CK D SN
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.1e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nmset_ SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN12 VSS SN net92 VPW N18_DNW L=1.8e-07 W=9.1e-07
MXN11 net92 cn net89 VPW N18_DNW L=1.8e-07 W=9.1e-07
MXN3 m nmin net89 VPW N18_DNW L=1.8e-07 W=9.1e-07
mXI6_MXNOE m c XI6_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNA1 XI6_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=8.9e-07
mXI54_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=7.9e-07
MXN9 ns cn net101 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 VSS s net101 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 ns nmset_ VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net099 CK VDD VNW P18_DNW L=1.8e-07 W=8.8e-07
MXP13 net099 c cn VNW P18_DNW L=1.8e-07 W=8.8e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.25e-06
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nmset_ SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP14 m nmin net091 VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP1 net091 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mXI6_MXPA1 XI6_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI6_MXPOEN m cn XI6_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=4.7e-07
mX_g7_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI54_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.57e-06
MXP12 ns c net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP11 net73 nmset_ net76 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP10 VDD s net76 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFSHQ_X4_A7TR Q VDD VNW VPW VSS CK D SN
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
MXN1 cn CK VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=7.2e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
mX_g5_MXNA1 nmset_ SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN14_2 VSS SN net92__2 VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN13_2 net92__2 cn net89__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MXN15_2 m nmin net89__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MXN15 m nmin net89 VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN13 net92 cn net89 VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN14 VSS SN net92 VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI6_MXNOE m c XI6_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNA1 XI6_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mX_g7_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI54_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=1.26e-06
MXN9 ns cn net101 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN10 VSS s net101 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 ns nmset_ VSS VPW N18_DNW L=1.8e-07 W=2.5e-07
MXN6_2 ns nmset_ VSS VPW N18_DNW L=1.8e-07 W=2.5e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=5.9e-07
MXP2 net099 CK VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP18 net099 c cn VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=7.1e-07
mX_g5_MXPA1 nmset_ SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 m SN VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP1_2 net091__2 c VDD VNW P18_DNW L=1.8e-07 W=8.4e-07
MXP17_2 m nmin net091__2 VNW P18_DNW L=1.8e-07 W=8.4e-07
MXP17 m nmin net091 VNW P18_DNW L=1.8e-07 W=8.4e-07
MXP1 net091 c VDD VNW P18_DNW L=1.8e-07 W=8.4e-07
mXI6_MXPA1 XI6_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI6_MXPOEN m cn XI6_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
mX_g7_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
mX_g7_MXPA1_3 nm m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI54_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.03e-06
mXI54_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.2e-06
MXP12 ns c net73 VNW P18_DNW L=1.8e-07 W=2.2e-07
MXP11 net73 nmset_ net76 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP10 VDD s net76 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFSHQ_X8_A7TR Q VDD VNW VPW VSS CK D SN
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=5.9e-07
MXN1 cn CK VSS VPW N18_DNW L=1.8e-07 W=5e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=7.2e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
mX_g5_MXNA1 nmset_ SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN14_2 VSS SN net63__2 VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN15_2 net63__2 cn net71__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MXN3_2 m nmin net71__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MXN3 m nmin net71 VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN15 net63 cn net71 VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN14 VSS SN net63 VPW N18_DNW L=1.8e-07 W=8.2e-07
mXI6_MXNOE m c XI6_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI6_MXNA1 XI6_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=7.6e-07
mX_g7_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
mXI54_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=1.26e-06
MXN9 ns cn net59 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN10 VSS s net59 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 ns nmset_ VSS VPW N18_DNW L=1.8e-07 W=2.5e-07
MXN6_2 ns nmset_ VSS VPW N18_DNW L=1.8e-07 W=2.5e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_3 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_4 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=5.9e-07
MXP2 net87 CK VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP18 net87 c cn VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=7.1e-07
mX_g5_MXPA1 nmset_ SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 m SN VDD VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP1_2 net101__2 c VDD VNW P18_DNW L=1.8e-07 W=8.4e-07
MXP17_2 m nmin net101__2 VNW P18_DNW L=1.8e-07 W=8.4e-07
MXP17 m nmin net101 VNW P18_DNW L=1.8e-07 W=8.4e-07
MXP1 net101 c VDD VNW P18_DNW L=1.8e-07 W=8.4e-07
mXI6_MXPA1 XI6_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI6_MXPOEN m cn XI6_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
mX_g7_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
mX_g7_MXPA1_3 nm m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI54_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=1.03e-06
mXI54_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.2e-06
MXP12 ns c net93 VNW P18_DNW L=1.8e-07 W=2.2e-07
MXP11 net93 nmset_ net89 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP10 VDD s net89 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_3 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_4 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFSQ_X1_A7TR Q VDD VNW VPW VSS CK D SN
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 X_g3_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNOE nm cn X_g3_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNOE nm c XI3_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNA1 XI3_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 m nm NSN VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI54_MXNOE s c m VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 s cn net84 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 NSN ns net84 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 NSN SN VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g3_MXPA1 X_g3_p1 D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPOEN nm c X_g3_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI3_MXPOEN nm cn XI3_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI3_MXPA1 XI3_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI54_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 s SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 s c net62 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP7 VDD ns net62 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT DFFSQ_X2_A7TR Q VDD VNW VPW VSS CK D SN
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 X_g3_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNOE nm cn X_g3_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNOE nm c XI3_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNA1 XI3_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 m nm NSN VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI54_MXNOE s c m VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 s cn net39 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 NSN ns net39 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 NSN SN VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.01e-06
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g3_MXPA1 X_g3_p1 D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPOEN nm c X_g3_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI3_MXPOEN nm cn XI3_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI3_MXPA1 XI3_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI54_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 s SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9 s c net53 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP7 VDD ns net53 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFSQ_X4_A7TR Q VDD VNW VPW VSS CK D SN
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 X_g3_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNOE nm cn X_g3_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNOE nm c XI3_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNA1 XI3_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 m nm NSN VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI54_MXNOE s c m VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 s cn net39 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 NSN ns net39 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 NSN SN VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.01e-06
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g3_MXPA1 X_g3_p1 D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPOEN nm c X_g3_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI3_MXPOEN nm cn XI3_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI3_MXPA1 XI3_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI54_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 s SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9 s c net53 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP7 VDD ns net53 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFSRHQ_X1_A7TR Q VDD VNW VPW VSS CK D RN SN
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN10 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nmset SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN13 VSS SN net62 VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN12 net62 cn net82 VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN1 m nmin net82 VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI9_MXNOE m c XI9_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI9_MXNA1 XI9_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 nm m net70 VPW N18_DNW L=1.8e-07 W=6.5e-07
MXN14 VSS RN net70 VPW N18_DNW L=1.8e-07 W=6.5e-07
MXN5 nm nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI64_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=5.5e-07
MXN18 ns cn net101 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN19 net101 RN net90 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN17 VSS s net90 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN16 ns nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net122 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP15 net122 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nmset SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP16 m nmin net128 VNW P18_DNW L=1.8e-07 W=6.3e-07
MXP1 net128 c VDD VNW P18_DNW L=1.8e-07 W=6.3e-07
mXI9_MXPOEN m cn XI9_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI9_MXPA1 XI9_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 nm m VDD VNW P18_DNW L=1.8e-07 W=8.3e-07
MXP18 net144 nmset VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP17 nm RN net144 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI64_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=6.9e-07
MXP23 ns nmset net112 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP22 net112 RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP19 ns c net108 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP21 net108 nmset net136 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP20 VDD s net136 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT DFFSRHQ_X2_A7TR Q VDD VNW VPW VSS CK D RN SN
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN10 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nmset SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN21 VSS SN net62 VPW N18_DNW L=1.8e-07 W=9.5e-07
MXN20 net62 cn net82 VPW N18_DNW L=1.8e-07 W=9.5e-07
MXN1 m nmin net82 VPW N18_DNW L=1.8e-07 W=9.5e-07
mXI9_MXNOE m c XI9_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI9_MXNA1 XI9_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 nm m net70 VPW N18_DNW L=1.8e-07 W=8.9e-07
MXN22 VSS RN net70 VPW N18_DNW L=1.8e-07 W=8.9e-07
MXN5 nm nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI64_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=7e-07
MXN18 ns cn net101 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN19 net101 RN net90 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN17 VSS s net90 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN16 ns nmset VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net122 CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
MXP15 net122 c cn VNW P18_DNW L=1.8e-07 W=8e-07
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nmset SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP25 m nmin net128 VNW P18_DNW L=1.8e-07 W=8.8e-07
MXP1 net128 c VDD VNW P18_DNW L=1.8e-07 W=8.8e-07
mXI9_MXPOEN m cn XI9_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI9_MXPA1 XI9_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP18 net144 nmset VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP17 nm RN net144 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI64_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=9.8e-07
MXP27 ns nmset net112 VNW P18_DNW L=1.8e-07 W=4.7e-07
MXP22 net112 RN VDD VNW P18_DNW L=1.8e-07 W=4.7e-07
MXP19 ns c net108 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP21 net108 nmset net136 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP20 VDD s net136 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFSRHQ_X4_A7TR Q VDD VNW VPW VSS CK D RN SN
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=5.5e-07
MXN10 cn CK VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=4.6e-07
mX_g5_MXNA1 nmset SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN24_2 VSS SN net62__2 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN23_2 net62__2 cn net82__2 VPW N18_DNW L=1.8e-07 W=6.6e-07
MXN1_2 m nmin net82__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MXN1 m nmin net82 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN23 net62 cn net82 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN24 VSS SN net62 VPW N18_DNW L=1.8e-07 W=8.4e-07
mXI9_MXNOE m c XI9_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI9_MXNA1 XI9_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN25_2 VSS RN net70__2 VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN3_2 nm m net70__2 VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN3 nm m net70 VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN25 VSS RN net70 VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN5 nm nmset VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mXI64_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN18 ns cn net101 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN19 net101 RN net90 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN17 VSS s net90 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN16 ns nmset VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=5.5e-07
MXP2 net122 CK VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
MXP28 net122 c cn VNW P18_DNW L=1.8e-07 W=1.23e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=9.5e-07
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=9.5e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=6.9e-07
mX_g5_MXPA1 nmset SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1_2 net128__2 c VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP29_2 m nmin net128__2 VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP29 m nmin net128 VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP1 net128 c VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
mXI9_MXPA1 XI9_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI9_MXPOEN m cn XI9_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 nm m VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP5_2 nm m VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP18 net144 nmset VDD VNW P18_DNW L=1.8e-07 W=5.3e-07
MXP30 nm RN net144 VNW P18_DNW L=1.8e-07 W=5.3e-07
mXI64_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=4.1e-07
mXI64_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.2e-06
MXP22 net112 RN VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
MXP31 ns nmset net112 VNW P18_DNW L=1.8e-07 W=8.7e-07
MXP19 ns c net108 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP21 net108 nmset net136 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP20 VDD s net136 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFSRHQ_X8_A7TR Q VDD VNW VPW VSS CK D RN SN
mX_g14_MXNA1 nck CK VSS VPW N18_DNW L=1.8e-07 W=5.5e-07
MXN10 cn CK VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g10_MXNA1 c nck VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=4.6e-07
mX_g5_MXNA1 nmset SN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN24_2 VSS SN net62__2 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN23_2 net62__2 cn net82__2 VPW N18_DNW L=1.8e-07 W=6.6e-07
MXN1_2 m nmin net82__2 VPW N18_DNW L=1.8e-07 W=7.6e-07
MXN1 m nmin net82 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN23 net62 cn net82 VPW N18_DNW L=1.8e-07 W=8.4e-07
MXN24 VSS SN net62 VPW N18_DNW L=1.8e-07 W=8.4e-07
mXI9_MXNOE m c XI9_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI9_MXNA1 XI9_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN25_2 VSS RN net70__2 VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN3_2 nm m net70__2 VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN3 nm m net70 VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN25 VSS RN net70 VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN5 nm nmset VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mXI64_MXNOE ns c nm VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN18 ns cn net101 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN19 net101 RN net90 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN17 VSS s net90 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN16 ns nmset VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_3 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_4 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 nck CK VDD VNW P18_DNW L=1.8e-07 W=5.5e-07
MXP2 net122 CK VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
MXP28 net122 c cn VNW P18_DNW L=1.8e-07 W=1.23e-06
mX_g10_MXPA1 c nck VDD VNW P18_DNW L=1.8e-07 W=9.5e-07
mX_g10_MXPA1_2 c nck VDD VNW P18_DNW L=1.8e-07 W=9.5e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=6.9e-07
mX_g5_MXPA1 nmset SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1_2 net128__2 c VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP29_2 m nmin net128__2 VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP29 m nmin net128 VNW P18_DNW L=1.8e-07 W=4.9e-07
MXP1 net128 c VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
mXI9_MXPA1 XI9_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI9_MXPOEN m cn XI9_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 nm m VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP5_2 nm m VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP18 net144 nmset VDD VNW P18_DNW L=1.8e-07 W=5.3e-07
MXP30 nm RN net144 VNW P18_DNW L=1.8e-07 W=5.3e-07
mXI64_MXPOEN ns cn nm VNW P18_DNW L=1.8e-07 W=4.1e-07
mXI64_MXPOEN_2 ns cn nm VNW P18_DNW L=1.8e-07 W=1.2e-06
MXP22 net112 RN VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
MXP31 ns nmset net112 VNW P18_DNW L=1.8e-07 W=8.7e-07
MXP19 ns c net108 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP21 net108 nmset net136 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP20 VDD s net136 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_3 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_4 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFSR_X1_A7TR Q QN VDD VNW VPW VSS CK D RN SN
mX_g3_MXNA1 X_g3_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNOE nm cn X_g3_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNOE nm c XI4_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNA1 XI4_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
mX_g5_MXNA1 NRN RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 m nm NSN VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN2 m NRN NSN VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI64_MXNOE s c m VPW N18_DNW L=1.8e-07 W=2.9e-07
MXN3 s NRN NSN VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 s cn net67 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN7 NSN ns net67 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 NSN SN VSS VPW N18_DNW L=1.8e-07 W=6e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g0_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g3_MXPA1 X_g3_p1 D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPOEN nm c X_g3_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXPOEN nm cn XI4_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXPA1 XI4_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g5_MXPA1 NRN RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net_NRN NRN VDD VNW P18_DNW L=1.8e-07 W=9e-07
MXP6 m nm net_NRN VNW P18_DNW L=1.8e-07 W=6.7e-07
MXP1 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 s SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI64_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=4.4e-07
MXP7 s c net77 VNW P18_DNW L=1.8e-07 W=2.2e-07
MXP9 net_NRN ns net77 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g0_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT DFFSR_X2_A7TR Q QN VDD VNW VPW VSS CK D RN SN
mX_g3_MXNA1 X_g3_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNOE nm cn X_g3_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNOE nm c XI4_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNA1 XI4_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
mX_g5_MXNA1 NRN RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 m nm NSN VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN2 m NRN NSN VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI64_MXNOE s c m VPW N18_DNW L=1.8e-07 W=3.6e-07
MXN3 s NRN NSN VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 s cn net106 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN9 NSN ns net106 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 NSN SN VSS VPW N18_DNW L=1.8e-07 W=8.4e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g0_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXPA1 X_g3_p1 D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPOEN nm c X_g3_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXPOEN nm cn XI4_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXPA1 XI4_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.09e-06
mX_g5_MXPA1 NRN RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net_NRN NRN VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP6 m nm net_NRN VNW P18_DNW L=1.8e-07 W=7.2e-07
MXP1 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 s SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI64_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=4.6e-07
MXP7 s c net75 VNW P18_DNW L=1.8e-07 W=2.2e-07
MXP9 net_NRN ns net75 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g0_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFSR_X4_A7TR Q QN VDD VNW VPW VSS CK D RN SN
mX_g3_MXNA1 X_g3_n1 D VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
mX_g3_MXNOE nm cn X_g3_n1 VPW N18_DNW L=1.8e-07 W=3.9e-07
mXI4_MXNOE nm c XI4_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI4_MXNA1 XI4_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
mX_g5_MXNA1 NRN RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 m nm NSN VPW N18_DNW L=1.8e-07 W=4.5e-07
MXN2 m NRN NSN VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI64_MXNOE s c m VPW N18_DNW L=1.8e-07 W=5.9e-07
MXN3 s NRN NSN VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 s cn net106 VPW N18_DNW L=1.8e-07 W=2.2e-07
MXN9 NSN ns net106 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 NSN SN VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g0_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXPA1 X_g3_p1 D VDD VNW P18_DNW L=1.8e-07 W=5.9e-07
mX_g3_MXPOEN nm c X_g3_p1 VNW P18_DNW L=1.8e-07 W=5.9e-07
mXI4_MXPOEN nm cn XI4_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXPA1 XI4_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g5_MXPA1 NRN RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net_NRN NRN VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP6 m nm net_NRN VNW P18_DNW L=1.8e-07 W=7.2e-07
MXP1 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 s SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI64_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=4.6e-07
MXP7 s c net75 VNW P18_DNW L=1.8e-07 W=2.2e-07
MXP9 net_NRN ns net75 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g0_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends

.SUBCKT DFFS_X1_A7TR Q QN VDD VNW VPW VSS CK D SN
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 X_g3_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNOE nm cn X_g3_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNOE nm c XI3_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNA1 XI3_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 m nm BSN VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI64_MXNOE s c m VPW N18_DNW L=1.8e-07 W=2.9e-07
MXN1 s cn net134 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 BSN ns net134 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 BSN SN VSS VPW N18_DNW L=1.8e-07 W=6e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g0_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g3_MXPA1 X_g3_p1 D VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
mX_g3_MXPOEN nm c X_g3_p1 VNW P18_DNW L=1.8e-07 W=7.3e-07
mXI3_MXPOEN nm cn XI3_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI3_MXPA1 XI3_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 m nm VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI64_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=4.4e-07
MXP1 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 s SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP7 s c net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 VDD ns net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g0_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT DFFS_X2_A7TR Q QN VDD VNW VPW VSS CK D SN
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 X_g3_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNOE nm cn X_g3_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNOE nm c XI3_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNA1 XI3_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 m nm BSN VPW N18_DNW L=1.8e-07 W=4.5e-07
mXI64_MXNOE s c m VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN1 s cn net134 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 BSN ns net134 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 BSN SN VSS VPW N18_DNW L=1.8e-07 W=6e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g0_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.09e-06
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g3_MXPA1 X_g3_p1 D VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
mX_g3_MXPOEN nm c X_g3_p1 VNW P18_DNW L=1.8e-07 W=7.3e-07
mXI3_MXPOEN nm cn XI3_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI3_MXPA1 XI3_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 m nm VDD VNW P18_DNW L=1.8e-07 W=6.1e-07
mXI64_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=6.1e-07
MXP1 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 s SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 s c net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 VDD ns net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g0_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFS_X4_A7TR Q QN VDD VNW VPW VSS CK D SN
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=3.1e-07
mX_g3_MXNA1 X_g3_n1 D VSS VPW N18_DNW L=1.8e-07 W=3.1e-07
mX_g3_MXNOE nm cn X_g3_n1 VPW N18_DNW L=1.8e-07 W=3.1e-07
mXI3_MXNOE nm c XI3_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNA1 XI3_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 m nm BSN VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN0_2 m nm BSN VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI64_MXNOE s c m VPW N18_DNW L=1.8e-07 W=7.3e-07
MXN1 s cn net134 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 BSN ns net134 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 BSN SN VSS VPW N18_DNW L=1.8e-07 W=1.15e-06
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g0_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
mX_g3_MXPA1 X_g3_p1 D VDD VNW P18_DNW L=1.8e-07 W=8.1e-07
mX_g3_MXPOEN nm c X_g3_p1 VNW P18_DNW L=1.8e-07 W=8.1e-07
mXI3_MXPOEN nm cn XI3_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI3_MXPA1 XI3_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 m nm VDD VNW P18_DNW L=1.8e-07 W=8e-07
mXI64_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=1.1e-06
MXP1 m SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 s SN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP8 s c net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 VDD ns net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g0_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFTR_X1_A7TR Q QN VDD VNW VPW VSS CK D RN
MXN4 net129 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 net132 D net129 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 nm cn net132 VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNOE nm c XI3_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI3_MXNA1 XI3_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=4.6e-07
mXI64_MXNOE s c m VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI4_MXNOE s cn XI4_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI4_MXNA1 XI4_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g11_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXP4 net62 RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 net62 D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP3 nm c net62 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI3_MXPOEN nm cn XI3_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI3_MXPA1 XI3_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=8.3e-07
mXI64_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=8.3e-07
mXI4_MXPOEN s c XI4_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI4_MXPA1 XI4_p1 ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g11_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT DFFTR_X2_A7TR Q QN VDD VNW VPW VSS CK D RN
MXN6 net129 RN VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
MXN5 net132 D net129 VPW N18_DNW L=1.8e-07 W=3.7e-07
MXN1 nm cn net132 VPW N18_DNW L=1.8e-07 W=3.7e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNOE nm c XI3_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI3_MXNA1 XI3_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=4.7e-07
mXI64_MXNOE s c m VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI4_MXNOE s cn XI4_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI4_MXNA1 XI4_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g11_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP4 net62 RN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 net62 D VDD VNW P18_DNW L=1.8e-07 W=4.6e-07
MXP5 nm c net62 VNW P18_DNW L=1.8e-07 W=4.6e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI3_MXPOEN nm cn XI3_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI3_MXPA1 XI3_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI64_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI4_MXPOEN s c XI4_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI4_MXPA1 XI4_p1 ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g11_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFFTR_X4_A7TR Q QN VDD VNW VPW VSS CK D RN
MXN8 net129 RN VSS VPW N18_DNW L=1.8e-07 W=7.2e-07
MXN7 net132 D net129 VPW N18_DNW L=1.8e-07 W=7.2e-07
MXN1 nm cn net132 VPW N18_DNW L=1.8e-07 W=7.2e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI3_MXNOE nm c XI3_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI3_MXNA1 XI3_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=1.17e-06
mXI64_MXNOE s c m VPW N18_DNW L=1.8e-07 W=5.6e-07
mXI64_MXNOE_2 s c m VPW N18_DNW L=1.8e-07 W=5.6e-07
mXI4_MXNOE s cn XI4_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI4_MXNA1 XI4_n1 ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 ns s VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
mX_g1_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g11_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g11_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP4 net62 RN VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
MXP0 net62 D VDD VNW P18_DNW L=1.8e-07 W=8.8e-07
MXP6 nm c net62 VNW P18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.25e-06
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI3_MXPOEN nm cn XI3_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI3_MXPA1 XI3_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.6e-07
mX_g5_MXPA1_2 m nm VDD VNW P18_DNW L=1.8e-07 W=5.3e-07
mX_g5_MXPA1_3 m nm VDD VNW P18_DNW L=1.8e-07 W=5.3e-07
mX_g5_MXPA1_4 m nm VDD VNW P18_DNW L=1.8e-07 W=5.3e-07
mXI64_MXPOEN s cn m VNW P18_DNW L=1.8e-07 W=9e-07
mXI64_MXPOEN_2 s cn m VNW P18_DNW L=1.8e-07 W=9e-07
mXI4_MXPOEN s c XI4_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI4_MXPA1 XI4_p1 ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 ns s VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
mX_g1_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g11_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g11_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFF_X1_A7TR Q QN VDD VNW VPW VSS CK D
mXI14_MXNA1 XI14_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI14_MXNOE nm cn XI14_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNOE nm c XI13_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNA1 XI13_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI12_MXNA1 XI12_n1 m VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI12_MXNOE ns c XI12_n1 VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI11_MXNOE ns cn XI11_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXNA1 XI11_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI14_MXPA1 XI14_p1 D VDD VNW P18_DNW L=1.8e-07 W=4.9e-07
mXI14_MXPOEN nm c XI14_p1 VNW P18_DNW L=1.8e-07 W=4.9e-07
mXI13_MXPOEN nm cn XI13_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPA1 XI13_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI12_MXPA1 XI12_p1 m VDD VNW P18_DNW L=1.8e-07 W=6.2e-07
mXI12_MXPOEN ns cn XI12_p1 VNW P18_DNW L=1.8e-07 W=6.2e-07
mXI11_MXPOEN ns c XI11_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXPA1 XI11_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT DFF_X2_A7TR Q QN VDD VNW VPW VSS CK D
mXI14_MXNA1 XI14_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI14_MXNOE nm cn XI14_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNOE nm c XI13_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNA1 XI13_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI12_MXNA1 XI12_n1 m VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI12_MXNOE ns c XI12_n1 VPW N18_DNW L=1.8e-07 W=5.8e-07
mXI11_MXNOE ns cn XI11_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXNA1 XI11_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI14_MXPA1 XI14_p1 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI14_MXPOEN nm c XI14_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI13_MXPOEN nm cn XI13_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPA1 XI13_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=8e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI12_MXPA1 XI12_p1 m VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI12_MXPOEN ns cn XI12_p1 VNW P18_DNW L=1.8e-07 W=8.7e-07
mXI11_MXPOEN ns c XI11_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXPA1 XI11_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DFF_X4_A7TR Q QN VDD VNW VPW VSS CK D
mXI14_MXNA1 XI14_n1 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI14_MXNOE nm cn XI14_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNOE nm c XI13_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNA1 XI13_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=3.5e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI12_MXNA1 XI12_n1 m VSS VPW N18_DNW L=1.8e-07 W=5.6e-07
mXI12_MXNA1_2 XI12_n1 m VSS VPW N18_DNW L=1.8e-07 W=5.6e-07
mXI12_MXNOE ns c XI12_n1 VPW N18_DNW L=1.8e-07 W=5.6e-07
mXI12_MXNOE_2 ns c XI12_n1 VPW N18_DNW L=1.8e-07 W=5.6e-07
mXI11_MXNOE ns cn XI11_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXNA1 XI11_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI14_MXPA1 XI14_p1 D VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI14_MXPOEN nm c XI14_p1 VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI13_MXPOEN nm cn XI13_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPA1 XI13_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=5.3e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI12_MXPA1 XI12_p1 m VDD VNW P18_DNW L=1.8e-07 W=8.4e-07
mXI12_MXPA1_2 XI12_p1 m VDD VNW P18_DNW L=1.8e-07 W=8.4e-07
mXI12_MXPOEN ns cn XI12_p1 VNW P18_DNW L=1.8e-07 W=8.4e-07
mXI12_MXPOEN_2 ns cn XI12_p1 VNW P18_DNW L=1.8e-07 W=8.4e-07
mXI11_MXPOEN ns c XI11_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI11_MXPA1 XI11_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g9_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=7.3e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DLY1_X1_A7TR Y VDD VNW VPW VSS A
mX_g1_MXNA1 nmin A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 nmin1 nmin VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 ny nmin1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXPA1 nmin A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 nmin1 nmin VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1 ny nmin1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=7e-07
.ends


.SUBCKT DLY1_X4_A7TR Y VDD VNW VPW VSS A
mX_g1_MXNA1 nmin A VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
MXN1 nmin1 nmin VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
MXN4 ny nmin1 VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g0_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g1_MXPA1 nmin A VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP2 nmin1 nmin VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP4 ny nmin1 VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DLY2_X1_A7TR Y VDD VNW VPW VSS A
mX_g1_MXNA1 nmin A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN6 nmin1 nmin VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN7 ny nmin1 VSS VPW N18_DNW L=3.6e-07 W=2.8e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXPA1 nmin A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 nmin1 nmin VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP7 ny nmin1 VDD VNW P18_DNW L=3.6e-07 W=4.2e-07
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=7e-07
.ends


.SUBCKT DLY2_X4_A7TR Y VDD VNW VPW VSS A
mX_g1_MXNA1 nmin A VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
MXN10 nmin1 nmin VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
MXN11 ny nmin1 VSS VPW N18_DNW L=3.6e-07 W=5.7e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g0_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g1_MXPA1 nmin A VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP7 nmin1 nmin VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP11 ny nmin1 VDD VNW P18_DNW L=3.6e-07 W=8.6e-07
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DLY3_X1_A7TR Y VDD VNW VPW VSS A
mX_g1_MXNA1 nmin A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN11 nmin1 nmin VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN12 ny nmin1 VSS VPW N18_DNW L=5.4e-07 W=2.8e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXPA1 nmin A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 nmin1 nmin VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP12 ny nmin1 VDD VNW P18_DNW L=5.4e-07 W=4.2e-07
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=7e-07
.ends


.SUBCKT DLY3_X4_A7TR Y VDD VNW VPW VSS A
mX_g1_MXNA1 nmin A VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
MXN16 nmin1 nmin VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
MXN17 ny nmin1 VSS VPW N18_DNW L=5.4e-07 W=5.7e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g0_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g1_MXPA1 nmin A VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP2 nmin1 nmin VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP17 ny nmin1 VDD VNW P18_DNW L=5.4e-07 W=8.6e-07
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT DLY4_X1_A7TR Y VDD VNW VPW VSS A
mX_g1_MXNA1 nmin A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN15 nmin1 nmin VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN17 ny nmin1 VSS VPW N18_DNW L=7.2e-07 W=2.8e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXPA1 nmin A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9 nmin1 nmin VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP18 ny nmin1 VDD VNW P18_DNW L=7.2e-07 W=4.2e-07
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=7e-07
.ends


.SUBCKT DLY4_X4_A7TR Y VDD VNW VPW VSS A
mX_g1_MXNA1 nmin A VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
MXN22 nmin1 nmin VSS VPW N18_DNW L=1.8e-07 W=5.7e-07
MXN24 ny nmin1 VSS VPW N18_DNW L=7.2e-07 W=5.7e-07
mX_g0_MXNA1 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g0_MXNA1_2 Y ny VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g1_MXPA1 nmin A VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP2 nmin1 nmin VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP25 ny nmin1 VDD VNW P18_DNW L=7.2e-07 W=8.6e-07
mX_g0_MXPA1 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y ny VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT EDFFHQ_X1_A7TR Q VDD VNW VPW VSS CK D E
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=3.8e-07
MX_t8 nmsi E nmin VPW N18_DNW L=1.8e-07 W=3.8e-07
mX_g6_MXNA1 nmen E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t45 nmsi nmen net104 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 VSS s net104 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t13 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 net132 CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c net132 VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
MXN2 VSS cn net98 VPW N18_DNW L=1.8e-07 W=5.4e-07
MX_t2 m nmsi net98 VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI5_MXNOE m c XI5_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1 XI5_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
MX_t0 ns c nm VPW N18_DNW L=1.8e-07 W=5.9e-07
mXI6_MXNOE ns cn XI6_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI6_MXNA1 XI6_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
MX_t9 nmin nmen nmsi VNW P18_DNW L=1.8e-07 W=5.8e-07
mX_g6_MXPA1 nmen E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1 nmsi E net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t47 VDD s net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 net132 CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t22 VDD CK net053 VNW P18_DNW L=1.8e-07 W=1.06e-06
MXP0 cn c net053 VNW P18_DNW L=1.8e-07 W=8e-07
mX_g10_MXPA1 c net132 VDD VNW P18_DNW L=1.8e-07 W=1.08e-06
MX_t3i2 net047 c VDD VNW P18_DNW L=1.8e-07 W=7.5e-07
MXP2 m nmsi net047 VNW P18_DNW L=1.8e-07 W=7.5e-07
mXI5_MXPOEN m cn XI5_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI5_MXPA1 XI5_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
MX_t1 nm cn ns VNW P18_DNW L=1.8e-07 W=1.19e-06
mXI6_MXPOEN ns c XI6_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI6_MXPA1 XI6_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT EDFFHQ_X2_A7TR Q VDD VNW VPW VSS CK D E
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
MX_t8 nmsi E nmin VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g6_MXNA1 nmen E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t45 nmsi nmen net104 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 VSS s net104 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t13 cn CK VSS VPW N18_DNW L=1.8e-07 W=3e-07
mX_g14_MXNA1 net132 CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c net132 VSS VPW N18_DNW L=1.8e-07 W=4.7e-07
MXN2 VSS cn net98 VPW N18_DNW L=1.8e-07 W=7.4e-07
MX_t2 m nmsi net98 VPW N18_DNW L=1.8e-07 W=7.4e-07
mXI5_MXNOE m c XI5_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1 XI5_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=8.7e-07
MX_t0 ns c nm VPW N18_DNW L=1.8e-07 W=7.1e-07
mXI6_MXNOE ns cn XI6_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI6_MXNA1 XI6_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t9 nmin nmen nmsi VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g6_MXPA1 nmen E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1 nmsi E net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t47 VDD s net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 net132 CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t22 VDD CK net053 VNW P18_DNW L=1.8e-07 W=1.06e-06
MXP0 cn c net053 VNW P18_DNW L=1.8e-07 W=8.5e-07
mX_g10_MXPA1 c net132 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t3i2 net047 c VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
MXP3 m nmsi net047 VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI5_MXPOEN m cn XI5_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI5_MXPA1 XI5_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.33e-06
MX_t1 nm cn ns VNW P18_DNW L=1.8e-07 W=1.23e-06
mXI6_MXPOEN ns c XI6_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI6_MXPA1 XI6_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.25e-06
.ends


.SUBCKT EDFFHQ_X4_A7TR Q VDD VNW VPW VSS CK D E
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t8 nmsi E nmin VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g6_MXNA1 nmen E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t45 nmsi nmen net104 VPW N18_DNW L=1.8e-07 W=4.6e-07
MXN3 VSS s net104 VPW N18_DNW L=1.8e-07 W=4.6e-07
MX_t13 cn CK VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
mX_g14_MXNA1 net132 CK VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
mX_g10_MXNA1 c net132 VSS VPW N18_DNW L=1.8e-07 W=7.5e-07
MXN2_2 VSS cn net98__2 VPW N18_DNW L=1.8e-07 W=6.4e-07
MX_t2_2 m nmsi net98__2 VPW N18_DNW L=1.8e-07 W=6.4e-07
MX_t2 m nmsi net98 VPW N18_DNW L=1.8e-07 W=6.4e-07
MXN2 VSS cn net98 VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI5_MXNOE m c XI5_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI5_MXNA1 XI5_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=7.8e-07
mX_g7_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=7.8e-07
MX_t0 ns c nm VPW N18_DNW L=1.8e-07 W=1.26e-06
mXI6_MXNOE ns cn XI6_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI6_MXNA1 XI6_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mX_g13_MXPA1_2 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
MX_t9 nmin nmen nmsi VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g6_MXPA1 nmen E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 nmsi E net73 VNW P18_DNW L=1.8e-07 W=6.8e-07
MX_t47 VDD s net73 VNW P18_DNW L=1.8e-07 W=6.8e-07
mX_g14_MXPA1 net132 CK VDD VNW P18_DNW L=1.8e-07 W=6.1e-07
MX_t22 VDD CK net053 VNW P18_DNW L=1.8e-07 W=1.36e-06
MXP4 cn c net053 VNW P18_DNW L=1.8e-07 W=1.36e-06
mX_g10_MXPA1 c net132 VDD VNW P18_DNW L=1.8e-07 W=1.05e-06
mX_g10_MXPA1_2 c net132 VDD VNW P18_DNW L=1.8e-07 W=1.04e-06
MX_t3i2_2 net047__2 c VDD VNW P18_DNW L=1.8e-07 W=8.2e-07
MXP3_2 m nmsi net047__2 VNW P18_DNW L=1.8e-07 W=8.2e-07
MXP3 m nmsi net047 VNW P18_DNW L=1.8e-07 W=1.1e-06
MX_t3i2 net047 c VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI5_MXPOEN m cn XI5_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI5_MXPA1 XI5_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.19e-06
mX_g7_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI6_MXPOEN ns c XI6_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI6_MXPA1 XI6_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t1 nm cn ns VNW P18_DNW L=1.8e-07 W=8.6e-07
MX_t1_2 nm cn ns VNW P18_DNW L=1.8e-07 W=1.4e-06
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT EDFFHQ_X8_A7TR Q VDD VNW VPW VSS CK D E
mX_g13_MXNA1 nmin D VSS VPW N18_DNW L=1.8e-07 W=8.6e-07
mX_g13_MXNA1_2 nmin D VSS VPW N18_DNW L=1.8e-07 W=8.6e-07
MX_t8 nmsi E nmin VPW N18_DNW L=1.8e-07 W=8.6e-07
MX_t8_2 nmsi E nmin VPW N18_DNW L=1.8e-07 W=8.6e-07
mX_g6_MXNA1 nmen E VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
MX_t45 nmsi nmen net104 VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN3 VSS s net104 VPW N18_DNW L=1.8e-07 W=8.2e-07
MX_t13 cn CK VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
mX_g14_MXNA1 net132 CK VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g14_MXNA1_2 net132 CK VSS VPW N18_DNW L=1.8e-07 W=5.5e-07
mX_g10_MXNA1 c net132 VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mX_g10_MXNA1_2 c net132 VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
MXN2_2 VSS cn net98__2 VPW N18_DNW L=1.8e-07 W=7.2e-07
MX_t2_2 m nmsi net98__2 VPW N18_DNW L=1.8e-07 W=4.8e-07
MX_t2_3 m nmsi net98__3 VPW N18_DNW L=1.8e-07 W=4.8e-07
MXN2_3 VSS cn net98__3 VPW N18_DNW L=1.8e-07 W=4.8e-07
MXN2_4 VSS cn net98__4 VPW N18_DNW L=1.8e-07 W=7.3e-07
MX_t2_4 m nmsi net98__4 VPW N18_DNW L=1.8e-07 W=4.8e-07
MX_t2 m nmsi net98 VPW N18_DNW L=1.8e-07 W=4.8e-07
MXN2 VSS cn net98 VPW N18_DNW L=1.8e-07 W=4.8e-07
mXI5_MXNOE m c XI5_n1 VPW N18_DNW L=1.8e-07 W=3e-07
mXI5_MXNA1 XI5_n1 nm VSS VPW N18_DNW L=1.8e-07 W=3e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=6.7e-07
mX_g7_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mX_g7_MXNA1_3 nm m VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mX_g7_MXNA1_4 nm m VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
MX_t0 ns c nm VPW N18_DNW L=1.8e-07 W=1.28e-06
MX_t0_2 ns c nm VPW N18_DNW L=1.8e-07 W=1.28e-06
mXI6_MXNOE ns cn XI6_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI6_MXNA1 XI6_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_3 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_4 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g13_MXPA1 nmin D VDD VNW P18_DNW L=1.8e-07 W=8.8e-07
mX_g13_MXPA1_2 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.2e-06
mX_g13_MXPA1_3 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.2e-06
mX_g13_MXPA1_4 nmin D VDD VNW P18_DNW L=1.8e-07 W=1.2e-06
MX_t9 nmin nmen nmsi VNW P18_DNW L=1.8e-07 W=1.3e-06
MX_t9_2 nmin nmen nmsi VNW P18_DNW L=1.8e-07 W=1.29e-06
mX_g6_MXPA1 nmen E VDD VNW P18_DNW L=1.8e-07 W=5.9e-07
MXP5 nmsi E net73 VNW P18_DNW L=1.8e-07 W=1.29e-06
MX_t47 VDD s net73 VNW P18_DNW L=1.8e-07 W=1.29e-06
mX_g14_MXPA1 net132 CK VDD VNW P18_DNW L=1.8e-07 W=1.09e-06
MX_t22_2 VDD CK net053__2 VNW P18_DNW L=1.8e-07 W=1.22e-06
MXP4_2 cn c net053__2 VNW P18_DNW L=1.8e-07 W=1.22e-06
MXP4 cn c net053 VNW P18_DNW L=1.8e-07 W=1.21e-06
MX_t22 VDD CK net053 VNW P18_DNW L=1.8e-07 W=1.21e-06
mX_g10_MXPA1 c net132 VDD VNW P18_DNW L=1.8e-07 W=1.37e-06
mX_g10_MXPA1_2 c net132 VDD VNW P18_DNW L=1.8e-07 W=1.37e-06
MX_t3i2_2 net047__2 c VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP3_2 m nmsi net047__2 VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP3_3 m nmsi net047__3 VNW P18_DNW L=1.8e-07 W=8.6e-07
MX_t3i2_3 net047__3 c VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MX_t3i2_4 net047__4 c VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP3_4 m nmsi net047__4 VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP3 m nmsi net047 VNW P18_DNW L=1.8e-07 W=8.6e-07
MX_t3i2 net047 c VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
mXI5_MXPOEN m cn XI5_p1 VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI5_MXPA1 XI5_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.37e-06
mX_g7_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=1.37e-06
mX_g7_MXPA1_3 nm m VDD VNW P18_DNW L=1.8e-07 W=1.37e-06
mX_g7_MXPA1_4 nm m VDD VNW P18_DNW L=1.8e-07 W=1.37e-06
mXI6_MXPOEN ns c XI6_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI6_MXPA1 XI6_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t1 nm cn ns VNW P18_DNW L=1.8e-07 W=6.9e-07
MX_t1_2 nm cn ns VNW P18_DNW L=1.8e-07 W=1.14e-06
MX_t1_3 nm cn ns VNW P18_DNW L=1.8e-07 W=1.64e-06
MX_t1_4 nm cn ns VNW P18_DNW L=1.8e-07 W=1.64e-06
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_3 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_4 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends

.SUBCKT EDFFTR_X1_A7TR Q QN VDD VNW VPW VSS CK D E RN
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g8_MXNA1 nmen E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 net122 s net140 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 net122 nmen net106 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 net107 E net106 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 net140 D net107 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t3 net106 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t19 nm cn net140 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI15_MXNOE nm c XI15_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI15_MXNA1 XI15_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI11_MXNA1 XI11_n1 m VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI11_MXNOE ns c XI11_n1 VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI5_MXNOE ns cn XI5_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI5_MXNA1 XI5_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g8_MXPA1 nmen E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP3 net77 s net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 VDD E net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t5 VDD nmen net76 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 net76 D net77 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1 VDD RN net77 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 net77 c nm VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI15_MXPOEN nm cn XI15_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI15_MXPA1 XI15_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI11_MXPA1 XI11_p1 m VDD VNW P18_DNW L=1.8e-07 W=6.2e-07
mXI11_MXPOEN ns cn XI11_p1 VNW P18_DNW L=1.8e-07 W=6.2e-07
mXI5_MXPOEN ns c XI5_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI5_MXPA1 XI5_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT EDFFTR_X2_A7TR Q QN VDD VNW VPW VSS CK D E RN
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mX_g8_MXNA1 nmen E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 net122 s net140 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 net122 nmen net106 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 net107 E net106 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 net140 D net107 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t3 net106 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t19 nm cn net140 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI15_MXNOE nm c XI15_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI15_MXNA1 XI15_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI11_MXNA1 XI11_n1 m VSS VPW N18_DNW L=1.8e-07 W=6.1e-07
mXI11_MXNOE ns c XI11_n1 VPW N18_DNW L=1.8e-07 W=6.1e-07
mXI5_MXNOE ns cn XI5_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI5_MXNA1 XI5_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=3.3e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=8.1e-07
mX_g8_MXPA1 nmen E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP3 net77 s net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 VDD E net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t5 VDD nmen net76 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 net76 D net77 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1 VDD RN net77 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 net77 c nm VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI15_MXPOEN nm cn XI15_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI15_MXPA1 XI15_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI11_MXPA1 XI11_p1 m VDD VNW P18_DNW L=1.8e-07 W=9.1e-07
mXI11_MXPOEN ns cn XI11_p1 VNW P18_DNW L=1.8e-07 W=9.1e-07
mXI5_MXPOEN ns c XI5_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI5_MXPA1 XI5_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=5e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT EDFFTR_X4_A7TR Q QN VDD VNW VPW VSS CK D E RN
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mX_g8_MXNA1 nmen E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 net122 s net140 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 net122 nmen net106 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 net107 E net106 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 net140 D net107 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t3 net106 RN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t19 nm cn net140 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI15_MXNOE nm c XI15_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI15_MXNA1 XI15_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI11_MXNA1 XI11_n1 m VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mXI11_MXNOE ns c XI11_n1 VPW N18_DNW L=1.8e-07 W=8.1e-07
mXI5_MXNOE ns cn XI5_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI5_MXNA1 XI5_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.04e-06
mX_g8_MXPA1 nmen E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP3 net77 s net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 VDD E net73 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t5 VDD nmen net76 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP0 net76 D net77 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1 VDD RN net77 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 net77 c nm VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI15_MXPOEN nm cn XI15_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI15_MXPA1 XI15_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=5.4e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI11_MXPA1 XI11_p1 m VDD VNW P18_DNW L=1.8e-07 W=1.2e-06
mXI11_MXPOEN ns cn XI11_p1 VNW P18_DNW L=1.8e-07 W=1.2e-06
mXI5_MXPOEN ns c XI5_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI5_MXPA1 XI5_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=8.3e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g9_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT EDFF_X1_A7TR Q QN VDD VNW VPW VSS CK D E
mX_g8_MXNA1 nmen E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 net120 s net129 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 net120 nmen VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 net123 E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 net129 D net123 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t19 nm cn net129 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNOE nm c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 XI1_n1 m VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXNOE ns c XI1_n1 VPW N18_DNW L=1.8e-07 W=4.2e-07
mXI2_MXNOE ns cn XI2_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI2_MXNA1 XI2_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g8_MXPA1 nmen E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1 net38 s net36 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP0 VDD E net36 VNW P18_DNW L=1.8e-07 W=6.5e-07
MX_t5 VDD nmen net39 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP3 net39 D net38 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP2 net38 c nm VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI0_MXPOEN nm cn XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 XI0_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI1_MXPA1 XI1_p1 m VDD VNW P18_DNW L=1.8e-07 W=6.2e-07
mXI1_MXPOEN ns cn XI1_p1 VNW P18_DNW L=1.8e-07 W=6.2e-07
mXI2_MXPOEN ns c XI2_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI2_MXPA1 XI2_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT EDFF_X2_A7TR Q QN VDD VNW VPW VSS CK D E
mX_g8_MXNA1 nmen E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 net120 s net129 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 net120 nmen VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 net123 E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 net129 D net123 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t19 nm cn net129 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNOE nm c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 XI1_n1 m VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI1_MXNOE ns c XI1_n1 VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI2_MXNOE ns cn XI2_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI2_MXNA1 XI2_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g8_MXPA1 nmen E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1 net38 s net36 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP0 VDD E net36 VNW P18_DNW L=1.8e-07 W=6.5e-07
MX_t5 VDD nmen net39 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP3 net39 D net38 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP2 net38 c nm VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI0_MXPOEN nm cn XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 XI0_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=8.2e-07
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI1_MXPA1 XI1_p1 m VDD VNW P18_DNW L=1.8e-07 W=9.3e-07
mXI1_MXPOEN ns cn XI1_p1 VNW P18_DNW L=1.8e-07 W=9.3e-07
mXI2_MXPOEN ns c XI2_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI2_MXPA1 XI2_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=5.4e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT EDFF_X4_A7TR Q QN VDD VNW VPW VSS CK D E
mX_g8_MXNA1 nmen E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 net120 s net129 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 net120 nmen VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 net123 E VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 net129 D net123 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t19 nm cn net129 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNOE nm c XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 XI0_n1 m VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 m nm VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
mX_g14_MXNA1 cn CK VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mX_g10_MXNA1 c cn VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 XI1_n1 m VSS VPW N18_DNW L=1.8e-07 W=8e-07
mXI1_MXNOE ns c XI1_n1 VPW N18_DNW L=1.8e-07 W=8e-07
mXI2_MXNOE ns cn XI2_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI2_MXNA1 XI2_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXNA1 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g9_MXNA1_2 QN s VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g8_MXPA1 nmen E VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1 net38 s net36 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP0 VDD E net36 VNW P18_DNW L=1.8e-07 W=6.5e-07
MX_t5 VDD nmen net39 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP3 net39 D net38 VNW P18_DNW L=1.8e-07 W=6.5e-07
MXP2 net38 c nm VNW P18_DNW L=1.8e-07 W=6.5e-07
mXI0_MXPOEN nm cn XI0_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI0_MXPA1 XI0_p1 m VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 m nm VDD VNW P18_DNW L=1.8e-07 W=5.4e-07
mX_g14_MXPA1 cn CK VDD VNW P18_DNW L=1.8e-07 W=1.05e-06
mX_g10_MXPA1 c cn VDD VNW P18_DNW L=1.8e-07 W=7.8e-07
mXI1_MXPA1 XI1_p1 m VDD VNW P18_DNW L=1.8e-07 W=1.2e-06
mXI1_MXPOEN ns cn XI1_p1 VNW P18_DNW L=1.8e-07 W=1.2e-06
mXI2_MXPOEN ns c XI2_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI2_MXPA1 XI2_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=8.7e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g9_MXPA1 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g9_MXPA1_2 QN s VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.subckt ENDCAPTIE11_A7TR VDD VNW VPW VSS 
*.CONNECT VNW VDD
*.CONNECT VPW VSS
.ends ENDCAPTIE11_A7TR









.SUBCKT FILLCAP16_A7TR VDD VNW VPW VSS
MXN0 net5 net3 VSS VPW N18_DNW L=7.5e-06 W=8.8e-07
MXP0 VDD net5 net3 VNW P18_DNW L=7.5e-06 W=1.32e-06
.ends


.SUBCKT FILLCAP32_A7TR VDD VNW VPW VSS
MXN0 net5 net3 VSS VPW N18_DNW L=1.646e-05 W=8.8e-07
MXP0 VDD net5 net3 VNW P18_DNW L=1.646e-05 W=1.32e-06
.ends


.SUBCKT FILLCAP4_A7TR VDD VNW VPW VSS
MXN0 net5 net3 VSS VPW N18_DNW L=7.8e-07 W=8.8e-07
MXP0 VDD net5 net3 VNW P18_DNW L=7.8e-07 W=1.32e-06
.ends


.SUBCKT FILLCAP64_A7TR VDD VNW VPW VSS
MXN0 net13 net14 VSS VPW N18_DNW L=3.437e-05 W=8.8e-07
MXP0 VDD net13 net14 VNW P18_DNW L=3.437e-05 W=1.32e-06
.ends


.SUBCKT FILLCAP8_A7TR VDD VNW VPW VSS
MXN0 net5 net3 VSS VPW N18_DNW L=3.02e-06 W=8.8e-07
MXP0 VDD net5 net3 VNW P18_DNW L=3.02e-06 W=1.32e-06
.ends


.subckt FILLTIE_A7TR VDD VNW VPW VSS 
*.CONNECT VNW VDD
*.CONNECT VPW VSS
.ends FILLTIE_A7TR


.SUBCKT HOLD_X1_A7TR Y VDD VNW VPW VSS
mXI6_MXNA1 net17 Y VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN0 net7 net17 VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
MX_t19 Y net17 net7 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI6_MXPA1 net17 Y VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t5 VDD net17 Y VNW P18_DNW L=1.8e-07 W=2.2e-07
.ends


.SUBCKT INV_X10_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_5 Y A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT INV_X12_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_5 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_6 Y A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_6 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT INV_X14_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_5 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_6 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_7 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_6 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_7 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT INV_X16_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_5 Y A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1_6 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_7 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_8 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_6 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_7 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_8 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT INV_X18_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_5 Y A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1_6 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_7 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_8 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_9 Y A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_6 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_7 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_8 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_9 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT INV_X1_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT INV_X20_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_5 Y A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1_6 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_7 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_8 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_9 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_10 Y A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_6 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_7 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_8 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_9 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_10 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT INV_X24_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_5 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_6 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_7 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_8 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_9 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_10 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_11 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_6 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_7 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_8 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_9 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_10 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_11 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT INV_X2_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT INV_X32_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_5 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_6 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_7 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_8 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_9 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_10 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_11 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_12 Y A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1_13 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_14 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_15 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_16 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_6 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_7 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_8 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_9 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_10 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_11 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_12 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_13 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_14 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_15 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_16 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT INV_X3_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
.ends


.SUBCKT INV_X4_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT INV_X5_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
.ends


.SUBCKT INV_X6_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT INV_X8_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI0_MXNA1_2 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT INV_XL_A7TR Y VDD VNW VPW VSS A
mXI0_MXNA1 Y A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT MDFFHQ_X1_A7TR Q VDD VNW VPW VSS CK D0 D1 S0
MX_t8 nmsi S0 nmin1 VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g13_MXNA1 nmin1 D1 VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g6_MXNA1 nms0 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t11 nmsi nms0 nmin0 VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g16_MXNA1 nmin0 D0 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
MX_t13 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 net109 CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c net109 VSS VPW N18_DNW L=1.8e-07 W=3.6e-07
MXN0 net135 cn VSS VPW N18_DNW L=1.8e-07 W=4.7e-07
MX_t2 m nmsi net135 VPW N18_DNW L=1.8e-07 W=4.7e-07
mXI13_MXNOE m c XI13_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNA1 XI13_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=6.2e-07
MX_t0 ns c nm VPW N18_DNW L=1.8e-07 W=5.2e-07
mXI12_MXNOE ns cn XI12_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI12_MXNA1 XI12_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MX_t9 nmin1 nms0 nmsi VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g13_MXPA1 nmin1 D1 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g6_MXPA1 nms0 S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 nmin0 S0 nmsi VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g16_MXPA1 nmin0 D0 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
MX_t22 VDD CK net50 VNW P18_DNW L=1.8e-07 W=8e-07
MXP0 cn c net50 VNW P18_DNW L=1.8e-07 W=8e-07
mX_g14_MXPA1 net109 CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c net109 VDD VNW P18_DNW L=1.8e-07 W=1.01e-06
MX_t3i2 net61 c VDD VNW P18_DNW L=1.8e-07 W=7.1e-07
MXP1 m nmsi net61 VNW P18_DNW L=1.8e-07 W=7.1e-07
mXI13_MXPOEN m cn XI13_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPA1 XI13_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.04e-06
MX_t1 nm cn ns VNW P18_DNW L=1.8e-07 W=1.04e-06
mXI12_MXPOEN ns c XI12_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI12_MXPA1 XI12_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT MDFFHQ_X2_A7TR Q VDD VNW VPW VSS CK D0 D1 S0
MX_t8 nmsi S0 nmin1 VPW N18_DNW L=1.8e-07 W=4.8e-07
mX_g13_MXNA1 nmin1 D1 VSS VPW N18_DNW L=1.8e-07 W=4.5e-07
mX_g6_MXNA1 nms0 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t11 nmsi nms0 nmin0 VPW N18_DNW L=1.8e-07 W=4.8e-07
mX_g16_MXNA1 nmin0 D0 VSS VPW N18_DNW L=1.8e-07 W=4.8e-07
MX_t13 cn CK VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g14_MXNA1 net109 CK VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXNA1 c net109 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MXN1 net135 cn VSS VPW N18_DNW L=1.8e-07 W=6e-07
MX_t2 m nmsi net135 VPW N18_DNW L=1.8e-07 W=6e-07
mXI13_MXNOE m c XI13_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNA1 XI13_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
MX_t0 ns c nm VPW N18_DNW L=1.8e-07 W=5.6e-07
mXI12_MXNOE ns cn XI12_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI12_MXNA1 XI12_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP4 nmin1 nms0 nmsi VNW P18_DNW L=1.8e-07 W=7.2e-07
mX_g13_MXPA1 nmin1 D1 VDD VNW P18_DNW L=1.8e-07 W=7.2e-07
mX_g6_MXPA1 nms0 S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 nmin0 S0 nmsi VNW P18_DNW L=1.8e-07 W=7.2e-07
mX_g16_MXPA1 nmin0 D0 VDD VNW P18_DNW L=1.8e-07 W=7.2e-07
MX_t22 VDD CK net50 VNW P18_DNW L=1.8e-07 W=8e-07
MXP2 cn c net50 VNW P18_DNW L=1.8e-07 W=8e-07
mX_g14_MXPA1 net109 CK VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g10_MXPA1 c net109 VDD VNW P18_DNW L=1.8e-07 W=1.14e-06
MX_t3i2 net61 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP5 m nmsi net61 VNW P18_DNW L=1.8e-07 W=9.2e-07
mXI13_MXPOEN m cn XI13_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPA1 XI13_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
MX_t1 nm cn ns VNW P18_DNW L=1.8e-07 W=1.12e-06
mXI12_MXPOEN ns c XI12_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI12_MXPA1 XI12_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.29e-06
.ends


.SUBCKT MDFFHQ_X4_A7TR Q VDD VNW VPW VSS CK D0 D1 S0
MX_t8 nmsi S0 nmin1 VPW N18_DNW L=1.8e-07 W=8.1e-07
mX_g13_MXNA1 nmin1 D1 VSS VPW N18_DNW L=1.8e-07 W=8.7e-07
mX_g6_MXNA1 nms0 S0 VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MX_t11 nmsi nms0 nmin0 VPW N18_DNW L=1.8e-07 W=8.4e-07
mX_g16_MXNA1 nmin0 D0 VSS VPW N18_DNW L=1.8e-07 W=8.7e-07
mX_g10_MXNA1 c net109 VSS VPW N18_DNW L=1.8e-07 W=7.1e-07
mX_g14_MXNA1 net109 CK VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
MX_t13 cn CK VSS VPW N18_DNW L=1.8e-07 W=4e-07
MXN3_2 net135__2 cn VSS VPW N18_DNW L=1.8e-07 W=4e-07
MX_t2_2 m nmsi net135__2 VPW N18_DNW L=1.8e-07 W=4e-07
MX_t2 m nmsi net135 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN3 net135 cn VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI13_MXNOE m c XI13_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI13_MXNA1 XI13_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
mX_g7_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=7.4e-07
MX_t0 ns c nm VPW N18_DNW L=1.8e-07 W=7.6e-07
MX_t0_2 ns c nm VPW N18_DNW L=1.8e-07 W=6.2e-07
mXI12_MXNOE ns cn XI12_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI12_MXNA1 XI12_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP4 nmin1 nms0 nmsi VNW P18_DNW L=1.8e-07 W=1.19e-06
mX_g13_MXPA1 nmin1 D1 VDD VNW P18_DNW L=1.8e-07 W=1.3e-06
mX_g6_MXPA1 nms0 S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t10 nmin0 S0 nmsi VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g16_MXPA1 nmin0 D0 VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g10_MXPA1 c net109 VDD VNW P18_DNW L=1.8e-07 W=1e-06
mX_g10_MXPA1_2 c net109 VDD VNW P18_DNW L=1.8e-07 W=1e-06
mX_g14_MXPA1 net109 CK VDD VNW P18_DNW L=1.8e-07 W=5.8e-07
MXP6 cn c net50 VNW P18_DNW L=1.8e-07 W=1.18e-06
MX_t22 VDD CK net50 VNW P18_DNW L=1.8e-07 W=1.18e-06
MX_t3i2_2 net61__2 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP7_2 m nmsi net61__2 VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP7 m nmsi net61 VNW P18_DNW L=1.8e-07 W=7.9e-07
MX_t3i2 net61 c VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mXI13_MXPOEN m cn XI13_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI13_MXPA1 XI13_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g7_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t1 nm cn ns VNW P18_DNW L=1.8e-07 W=1.38e-06
MX_t1_2 nm cn ns VNW P18_DNW L=1.8e-07 W=1.38e-06
mXI12_MXPOEN ns c XI12_p1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI12_MXPA1 XI12_p1 s VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MDFFHQ_X8_A7TR Q VDD VNW VPW VSS CK D0 D1 S0
MX_t8 nmsi S0 nmin1 VPW N18_DNW L=1.8e-07 W=8.1e-07
MX_t8_2 nmsi S0 nmin1 VPW N18_DNW L=1.8e-07 W=8.1e-07
mX_g13_MXNA1 nmin1 D1 VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g13_MXNA1_2 nmin1 D1 VSS VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g6_MXNA1 nms0 S0 VSS VPW N18_DNW L=1.8e-07 W=4.6e-07
MX_t11 nmsi nms0 nmin0 VPW N18_DNW L=1.8e-07 W=8.2e-07
MX_t11_2 nmsi nms0 nmin0 VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g16_MXNA1 nmin0 D0 VSS VPW N18_DNW L=1.8e-07 W=6e-07
mX_g16_MXNA1_2 nmin0 D0 VSS VPW N18_DNW L=1.8e-07 W=9.4e-07
MX_t2_2 m nmsi net135__2 VPW N18_DNW L=1.8e-07 W=6.3e-07
MXN3_2 net135__2 cn VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
MXN3_3 net135__3 cn VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
MX_t2_3 m nmsi net135__3 VPW N18_DNW L=1.8e-07 W=6.3e-07
MX_t2 m nmsi net135 VPW N18_DNW L=1.8e-07 W=6.9e-07
MXN3 net135 cn VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
mXI13_MXNOE m c XI13_n1 VPW N18_DNW L=1.8e-07 W=2.9e-07
mXI13_MXNA1 XI13_n1 nm VSS VPW N18_DNW L=1.8e-07 W=2.9e-07
mX_g7_MXNA1 nm m VSS VPW N18_DNW L=1.8e-07 W=9.1e-07
mX_g7_MXNA1_2 nm m VSS VPW N18_DNW L=1.8e-07 W=9.1e-07
mX_g7_MXNA1_3 nm m VSS VPW N18_DNW L=1.8e-07 W=9.1e-07
MX_t13 cn CK VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mX_g14_MXNA1 net109 CK VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g10_MXNA1 c net109 VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
mX_g10_MXNA1_2 c net109 VSS VPW N18_DNW L=1.8e-07 W=6.3e-07
MX_t0 ns c nm VPW N18_DNW L=1.8e-07 W=8.7e-07
MX_t0_2 ns c nm VPW N18_DNW L=1.8e-07 W=8.6e-07
MX_t0_3 ns c nm VPW N18_DNW L=1.8e-07 W=8.6e-07
mXI12_MXNOE ns cn XI12_n1 VPW N18_DNW L=1.8e-07 W=2.2e-07
mXI12_MXNA1 XI12_n1 s VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXNA1 s ns VSS VPW N18_DNW L=1.8e-07 W=2.2e-07
mX_g1_MXNA1 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_2 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_3 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1_4 Q ns VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXP4 nmin1 nms0 nmsi VNW P18_DNW L=1.8e-07 W=1.19e-06
MXP4_2 nmin1 nms0 nmsi VNW P18_DNW L=1.8e-07 W=1.19e-06
mX_g13_MXPA1 nmin1 D1 VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
mX_g13_MXPA1_2 nmin1 D1 VDD VNW P18_DNW L=1.8e-07 W=1.23e-06
mX_g6_MXPA1 nms0 S0 VDD VNW P18_DNW L=1.8e-07 W=6.2e-07
MX_t10 nmin0 S0 nmsi VNW P18_DNW L=1.8e-07 W=1.23e-06
MX_t10_2 nmin0 S0 nmsi VNW P18_DNW L=1.8e-07 W=1.23e-06
mX_g16_MXPA1 nmin0 D0 VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g16_MXPA1_2 nmin0 D0 VDD VNW P18_DNW L=1.8e-07 W=9.5e-07
MXP7_2 m nmsi net61__2 VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t3i2_2 net61__2 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t3i2_3 net61__3 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP7_3 m nmsi net61__3 VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP7 m nmsi net61 VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t3i2 net61 c VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mXI13_MXPOEN m cn XI13_p1 VNW P18_DNW L=1.8e-07 W=4.3e-07
mXI13_MXPA1 XI13_p1 nm VDD VNW P18_DNW L=1.8e-07 W=4.3e-07
mX_g7_MXPA1 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g7_MXPA1_2 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g7_MXPA1_3 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g7_MXPA1_4 nm m VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
MX_t22_2 VDD CK net50__2 VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP6_2 cn c net50__2 VNW P18_DNW L=1.8e-07 W=9.2e-07
MXP6 cn c net50 VNW P18_DNW L=1.8e-07 W=1.19e-06
MX_t22 VDD CK net50 VNW P18_DNW L=1.8e-07 W=1.19e-06
mX_g14_MXPA1 net109 CK VDD VNW P18_DNW L=1.8e-07 W=1.03e-06
mX_g10_MXPA1 c net109 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g10_MXPA1_2 c net109 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t1 nm cn ns VNW P18_DNW L=1.8e-07 W=1.27e-06
MX_t1_2 nm cn ns VNW P18_DNW L=1.8e-07 W=1.28e-06
MX_t1_3 nm cn ns VNW P18_DNW L=1.8e-07 W=1.28e-06
mXI12_MXPOEN ns c XI12_p1 VNW P18_DNW L=1.8e-07 W=2.2e-07
mXI12_MXPA1 XI12_p1 s VDD VNW P18_DNW L=1.8e-07 W=2.2e-07
mX_g2_MXPA1 s ns VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g1_MXPA1_2 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_3 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1_4 Q ns VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MX2_X12_A7TR Y VDD VNW VPW VSS A B S0
mX_g1_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g3_MXNA1 net36 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t2 nmin S0 net36 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN3 nmin nmsel net42 VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1 net42 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_3 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_4 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_5 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_6 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g3_MXPA1 net36 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t3 net36 nmsel nmin VNW P18_DNW L=1.8e-07 W=8.9e-07
MXP1 net42 S0 nmin VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g2_MXPA1 net42 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_3 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_4 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_5 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_6 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MX2_X1_A7TR Y VDD VNW VPW VSS A B S0
mX_g1_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 net36 B VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
MX_t2 nmin S0 net36 VPW N18_DNW L=1.8e-07 W=4.3e-07
MXN0 nmin nmsel net38 VPW N18_DNW L=1.8e-07 W=4.3e-07
mX_g2_MXNA1 net38 A VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
mX_g0_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g1_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 net36 B VDD VNW P18_DNW L=1.8e-07 W=6.4e-07
MX_t3 net36 nmsel nmin VNW P18_DNW L=1.8e-07 W=6.4e-07
MXP0 net38 S0 nmin VNW P18_DNW L=1.8e-07 W=6.4e-07
mX_g2_MXPA1 net38 A VDD VNW P18_DNW L=1.8e-07 W=6.4e-07
mX_g0_MXPA1 Y nmin VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT MX2_X2_A7TR Y VDD VNW VPW VSS A B S0
mX_g1_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 net36 B VSS VPW N18_DNW L=1.8e-07 W=5.8e-07
MX_t2 nmin S0 net36 VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN0 nmin nmsel net38 VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g2_MXNA1 net38 A VSS VPW N18_DNW L=1.8e-07 W=6e-07
mX_g0_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 net36 B VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
MX_t3 net36 nmsel nmin VNW P18_DNW L=1.8e-07 W=7.6e-07
MXP0 net38 S0 nmin VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g2_MXPA1 net38 A VDD VNW P18_DNW L=1.8e-07 W=9.2e-07
mX_g0_MXPA1 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.26e-06
.ends


.SUBCKT MX2_X3_A7TR Y VDD VNW VPW VSS A B S0
mX_g1_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g3_MXNA1 net36 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t2 nmin S0 net36 VPW N18_DNW L=1.8e-07 W=7.8e-07
MXN1 nmin nmsel net42 VPW N18_DNW L=1.8e-07 W=7.8e-07
mX_g2_MXNA1 net42 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=7.8e-07
mX_g0_MXNA1_2 Y nmin VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g1_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g3_MXPA1 net36 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t3 net36 nmsel nmin VNW P18_DNW L=1.8e-07 W=9.9e-07
MXP0 net42 S0 nmin VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g2_MXPA1 net42 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1e-06
mX_g0_MXPA1_2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT MX2_X4_A7TR Y VDD VNW VPW VSS A B S0
mX_g1_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g3_MXNA1 net36 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t2 nmin S0 net36 VPW N18_DNW L=1.8e-07 W=7.8e-07
MXN1 nmin nmsel net42 VPW N18_DNW L=1.8e-07 W=7.8e-07
mX_g2_MXNA1 net42 A VSS VPW N18_DNW L=1.8e-07 W=8.1e-07
mX_g0_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g3_MXPA1 net36 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t3 net36 nmsel nmin VNW P18_DNW L=1.8e-07 W=9.9e-07
MXP0 net42 S0 nmin VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g2_MXPA1 net42 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MX2_X6_A7TR Y VDD VNW VPW VSS A B S0
mX_g1_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g3_MXNA1 net36 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t2 nmin S0 net36 VPW N18_DNW L=1.8e-07 W=7.8e-07
MXN1 nmin nmsel net42 VPW N18_DNW L=1.8e-07 W=7.8e-07
mX_g2_MXNA1 net42 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_3 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g3_MXPA1 net36 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t3 net36 nmsel nmin VNW P18_DNW L=1.8e-07 W=9.9e-07
MXP0 net42 S0 nmin VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g2_MXPA1 net42 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_3 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends

.SUBCKT MX2_X8_A7TR Y VDD VNW VPW VSS A B S0
mX_g1_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g3_MXNA1 net36 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t2 nmin S0 net36 VPW N18_DNW L=1.8e-07 W=7.8e-07
MXN1 nmin nmsel net42 VPW N18_DNW L=1.8e-07 W=7.8e-07
mX_g2_MXNA1 net42 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_3 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_4 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g3_MXPA1 net36 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t3 net36 nmsel nmin VNW P18_DNW L=1.8e-07 W=9.5e-07
MXP0 net42 S0 nmin VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g2_MXPA1 net42 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_3 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_4 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MX2_XL_A7TR Y VDD VNW VPW VSS A B S0
mX_g1_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 net36 B VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MX_t2 nmin S0 net36 VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN1 nmin nmsel net38 VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXNA1 net38 A VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g0_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 net36 B VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t3 net36 nmsel nmin VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1 net38 S0 nmin VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 net38 A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g0_MXPA1 Y nmin VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT MX3_X1_A7TR Y VDD VNW VPW VSS A B C S0 S1
mX_g2_MXNA1 net73 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g4_MXNA1 net69 B VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
MX_t6 nmin0in1 S0 net69 VPW N18_DNW L=1.8e-07 W=6.4e-07
MX_t4 nmin0in1 net73 net71 VPW N18_DNW L=1.8e-07 W=6.4e-07
mX_g3_MXNA1 net71 A VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mX_g1_MXNA1 net75 S1 VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MX_t0 net66 net75 nmin0in1 VPW N18_DNW L=1.8e-07 W=6.4e-07
MX_t2 net66 S1 nmin2 VPW N18_DNW L=1.8e-07 W=4.3e-07
mX_g5_MXNA1 nmin2 C VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
mX_g0_MXNA1 Y net66 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g2_MXPA1 net73 S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g4_MXPA1 net69 B VDD VNW P18_DNW L=1.8e-07 W=8.1e-07
MX_t7 net69 net73 nmin0in1 VNW P18_DNW L=1.8e-07 W=8.1e-07
MX_t5 net71 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=9.6e-07
mX_g3_MXPA1 net71 A VDD VNW P18_DNW L=1.8e-07 W=9.6e-07
mX_g1_MXPA1 net75 S1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t1 nmin0in1 S1 net66 VNW P18_DNW L=1.8e-07 W=9.6e-07
MX_t3 nmin2 net75 net66 VNW P18_DNW L=1.8e-07 W=6.4e-07
mX_g5_MXPA1 nmin2 C VDD VNW P18_DNW L=1.8e-07 W=6.4e-07
mX_g0_MXPA1 Y net66 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT MX3_X2_A7TR Y VDD VNW VPW VSS A B C S0 S1
mX_g2_MXNA1 net73 S0 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g4_MXNA1 net69 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t6 nmin0in1 S0 net69 VPW N18_DNW L=1.8e-07 W=8.2e-07
MX_t4 nmin0in1 net73 net71 VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1 net71 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 net75 S1 VSS VPW N18_DNW L=1.8e-07 W=3e-07
MX_t0 net66 net75 nmin0in1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t2 net66 S1 nmin2 VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g5_MXNA1 nmin2 C VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g0_MXNA1 Y net66 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXPA1 net73 S0 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g4_MXPA1 net69 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t7 net69 net73 nmin0in1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t5 net71 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g3_MXPA1 net71 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1 net75 S1 VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
MX_t1 nmin0in1 S1 net66 VNW P18_DNW L=1.8e-07 W=1.26e-06
MX_t3 nmin2 net75 net66 VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g5_MXPA1 nmin2 C VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g0_MXPA1 Y net66 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MX3_X4_A7TR Y VDD VNW VPW VSS A B C S0 S1
mX_g2_MXNA1 net73 S0 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g4_MXNA1 net69 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t6 nmin0in1 S0 net69 VPW N18_DNW L=1.8e-07 W=8.2e-07
MX_t4 nmin0in1 net73 net71 VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1 net71 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 net75 S1 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
MX_t0 net66 net75 nmin0in1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t2 net66 S1 nmin2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g5_MXNA1 nmin2 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 Y net66 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 Y net66 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXPA1 net73 S0 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g4_MXPA1 net69 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t7 net69 net73 nmin0in1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t5 net71 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g3_MXPA1 net71 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1 net75 S1 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
MX_t1 nmin0in1 S1 net66 VNW P18_DNW L=1.8e-07 W=1.26e-06
MX_t3 nmin2 net75 net66 VNW P18_DNW L=1.8e-07 W=1.17e-06
mX_g5_MXPA1 nmin2 C VDD VNW P18_DNW L=1.8e-07 W=1.17e-06
mX_g0_MXPA1 Y net66 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y net66 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MX3_X8_A7TR Y VDD VNW VPW VSS A B C S0 S1
mX_g2_MXNA1 net73 S0 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g4_MXNA1 net69 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t6 nmin0in1 S0 net69 VPW N18_DNW L=1.8e-07 W=8.2e-07
MX_t4 nmin0in1 net73 net71 VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1 net71 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 net75 S1 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
MX_t0 net66 net75 nmin0in1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t2 net66 S1 nmin2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g5_MXNA1 nmin2 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 Y net66 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 Y net66 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_3 Y net66 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_4 Y net66 VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g2_MXPA1 net73 S0 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g4_MXPA1 net69 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t7 net69 net73 nmin0in1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t5 net71 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g3_MXPA1 net71 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1 net75 S1 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
MXP0 nmin0in1 S1 net66 VNW P18_DNW L=1.8e-07 W=1.26e-06
MX_t3 nmin2 net75 net66 VNW P18_DNW L=1.8e-07 W=1.17e-06
mX_g5_MXPA1 nmin2 C VDD VNW P18_DNW L=1.8e-07 W=1.17e-06
mX_g0_MXPA1 Y net66 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y net66 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_3 Y net66 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_4 Y net66 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MX3_XL_A7TR Y VDD VNW VPW VSS A B C S0 S1
mX_g2_MXNA1 net73 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g4_MXNA1 net69 B VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
MX_t6 nmin0in1 S0 net69 VPW N18_DNW L=1.8e-07 W=3.9e-07
MXN0 nmin0in1 net73 net71 VPW N18_DNW L=1.8e-07 W=3.9e-07
mX_g3_MXNA1 net71 A VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
mX_g1_MXNA1 net75 S1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 net66 net75 nmin0in1 VPW N18_DNW L=1.8e-07 W=4.2e-07
MX_t2 net66 S1 nmin2 VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 nmin2 C VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g0_MXNA1 Y net66 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXPA1 net73 S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g4_MXPA1 net69 B VDD VNW P18_DNW L=1.8e-07 W=5.9e-07
MX_t7 net69 net73 nmin0in1 VNW P18_DNW L=1.8e-07 W=5.9e-07
MXP0 net71 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=5.9e-07
mX_g3_MXPA1 net71 A VDD VNW P18_DNW L=1.8e-07 W=5.9e-07
mX_g1_MXPA1 net75 S1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1 nmin0in1 S1 net66 VNW P18_DNW L=1.8e-07 W=5.9e-07
MX_t3 nmin2 net75 net66 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 nmin2 C VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g0_MXPA1 Y net66 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT MX4_X1_A7TR Y VDD VNW VPW VSS A B C D S0 S1
mXI17_MXNA1 net100 C VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
MXN0 nmin2in3 nmsel0 net100 VPW N18_DNW L=1.8e-07 W=6.4e-07
MX_t10 nmin2in3 S0 net98 VPW N18_DNW L=1.8e-07 W=6.4e-07
mX_g6_MXNA1 net98 D VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mX_g2_MXNA1 nmsel0 S0 VSS VPW N18_DNW L=1.8e-07 W=4.7e-07
mXI18_MXNA1 net102 B VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
MXN1 nmin0in1 S0 net102 VPW N18_DNW L=1.8e-07 W=6.4e-07
MXN2 nmin0in1 nmsel0 net104 VPW N18_DNW L=1.8e-07 W=6.4e-07
mXI19_MXNA1 net104 A VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mX_g1_MXNA1 nmsel1 S1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 net97 nmsel1 nmin0in1 VPW N18_DNW L=1.8e-07 W=6.4e-07
MXN3 net97 S1 nmin2in3 VPW N18_DNW L=1.8e-07 W=6.4e-07
mX_g0_MXNA1 Y net97 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI17_MXPA1 net100 C VDD VNW P18_DNW L=1.8e-07 W=9.6e-07
MX_t9 net100 S0 nmin2in3 VNW P18_DNW L=1.8e-07 W=8.6e-07
MX_t11 net98 nmsel0 nmin2in3 VNW P18_DNW L=1.8e-07 W=9.6e-07
mX_g6_MXPA1 net98 D VDD VNW P18_DNW L=1.8e-07 W=9.6e-07
mX_g2_MXPA1 nmsel0 S0 VDD VNW P18_DNW L=1.8e-07 W=7.5e-07
mXI18_MXPA1 net102 B VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
MX_t7 net102 nmsel0 nmin0in1 VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP0 net104 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=9.6e-07
mXI19_MXPA1 net104 A VDD VNW P18_DNW L=1.8e-07 W=9.6e-07
mX_g1_MXPA1 nmsel1 S1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 nmin0in1 S1 net97 VNW P18_DNW L=1.8e-07 W=9.6e-07
MXP1 nmin2in3 nmsel1 net97 VNW P18_DNW L=1.8e-07 W=9.6e-07
mX_g0_MXPA1 Y net97 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT MX4_X2_A7TR Y VDD VNW VPW VSS A B C D S0 S1
mXI17_MXNA1 net100 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN0 nmin2in3 nmsel0 net100 VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t10 nmin2in3 S0 net98 VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g6_MXNA1 net98 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1 nmsel0 S0 VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI18_MXNA1 net102 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN1 nmin0in1 S0 net102 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN2 nmin0in1 nmsel0 net104 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI19_MXNA1 net104 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 nmsel1 S1 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
MXN6 net97 nmsel1 nmin0in1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN7 net97 S1 nmin2in3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 Y net97 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI17_MXPA1 net100 C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t9 net100 S0 nmin2in3 VNW P18_DNW L=1.8e-07 W=1.26e-06
MX_t11 net98 nmsel0 nmin2in3 VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g6_MXPA1 net98 D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1 nmsel0 S0 VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI18_MXPA1 net102 B VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
MX_t7 net102 nmsel0 nmin0in1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP3 net104 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI19_MXPA1 net104 A VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
mX_g1_MXPA1 nmsel1 S1 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
MXP4 nmin0in1 S1 net97 VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP1 nmin2in3 nmsel1 net97 VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g0_MXPA1 Y net97 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MX4_X4_A7TR Y VDD VNW VPW VSS A B C D S0 S1
mXI17_MXNA1 net100 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN0 nmin2in3 nmsel0 net100 VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t10 nmin2in3 S0 net98 VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g6_MXNA1 net98 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1 nmsel0 S0 VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI18_MXNA1 net102 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN1 nmin0in1 S0 net102 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN2 nmin0in1 nmsel0 net104 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI19_MXNA1 net104 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 nmsel1 S1 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
MXN7 net97 nmsel1 nmin0in1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN5 net97 S1 nmin2in3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 Y net97 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 Y net97 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI17_MXPA1 net100 C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t9 net100 S0 nmin2in3 VNW P18_DNW L=1.8e-07 W=1.26e-06
MX_t11 net98 nmsel0 nmin2in3 VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g6_MXPA1 net98 D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1 nmsel0 S0 VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI18_MXPA1 net102 B VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
MX_t7 net102 nmsel0 nmin0in1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP3 net104 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=1.26e-06
mXI19_MXPA1 net104 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g1_MXPA1 nmsel1 S1 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
MXP4 nmin0in1 S1 net97 VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP1 nmin2in3 nmsel1 net97 VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g0_MXPA1 Y net97 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y net97 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MX4_X8_A7TR Y VDD VNW VPW VSS A B C D S0 S1
mXI17_MXNA1 net100 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN0 nmin2in3 nmsel0 net100 VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t10 nmin2in3 S0 net98 VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g6_MXNA1 net98 D VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1 nmsel0 S0 VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI18_MXNA1 net102 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN1 nmin0in1 S0 net102 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN2 nmin0in1 nmsel0 net104 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI19_MXNA1 net104 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 nmsel1 S1 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
MXN7 net97 nmsel1 nmin0in1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN5 net97 S1 nmin2in3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 Y net97 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 Y net97 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_3 Y net97 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_4 Y net97 VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI17_MXPA1 net100 C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t9 net100 S0 nmin2in3 VNW P18_DNW L=1.8e-07 W=1.26e-06
MX_t11 net98 nmsel0 nmin2in3 VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g6_MXPA1 net98 D VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1 nmsel0 S0 VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI18_MXPA1 net102 B VDD VNW P18_DNW L=1.8e-07 W=1.28e-06
MX_t7 net102 nmsel0 nmin0in1 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP3 net104 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI19_MXPA1 net104 A VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
mX_g1_MXPA1 nmsel1 S1 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
MXP4 nmin0in1 S1 net97 VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP1 nmin2in3 nmsel1 net97 VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g0_MXPA1 Y net97 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y net97 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_3 Y net97 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_4 Y net97 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MX4_XL_A7TR Y VDD VNW VPW VSS A B C D S0 S1
mXI23_MXNA1 net100 C VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
MXN5 nmin2in3 net0110 net100 VPW N18_DNW L=1.8e-07 W=3.9e-07
MX_t10 nmin2in3 S0 net98 VPW N18_DNW L=1.8e-07 W=3.9e-07
mX_g6_MXNA1 net98 D VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
mX_g2_MXNA1 net0110 S0 VSS VPW N18_DNW L=1.8e-07 W=3e-07
mXI24_MXNA1 net102 B VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
MXN6 nmin0in1 S0 net102 VPW N18_DNW L=1.8e-07 W=3.9e-07
MXN7 nmin0in1 net0110 net104 VPW N18_DNW L=1.8e-07 W=3.9e-07
mXI25_MXNA1 net104 A VSS VPW N18_DNW L=1.8e-07 W=3.9e-07
mX_g1_MXNA1 nmsel1 S1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN10 net97 nmsel1 nmin0in1 VPW N18_DNW L=1.8e-07 W=3.9e-07
MXN11 net97 S1 nmin2in3 VPW N18_DNW L=1.8e-07 W=3.9e-07
mX_g0_MXNA1 Y net97 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI23_MXPA1 net100 C VDD VNW P18_DNW L=1.8e-07 W=5.9e-07
MXP3 net100 S0 nmin2in3 VNW P18_DNW L=1.8e-07 W=5.9e-07
MX_t11 net98 net0110 nmin2in3 VNW P18_DNW L=1.8e-07 W=5.9e-07
mX_g6_MXPA1 net98 D VDD VNW P18_DNW L=1.8e-07 W=5.9e-07
mX_g2_MXPA1 net0110 S0 VDD VNW P18_DNW L=1.8e-07 W=4.5e-07
mXI24_MXPA1 net102 B VDD VNW P18_DNW L=1.8e-07 W=5.9e-07
MXP4 net102 net0110 nmin0in1 VNW P18_DNW L=1.8e-07 W=5.9e-07
MXP8 net104 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=5.9e-07
mXI25_MXPA1 net104 A VDD VNW P18_DNW L=1.8e-07 W=5.9e-07
mX_g1_MXPA1 nmsel1 S1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP9 nmin0in1 S1 net97 VNW P18_DNW L=1.8e-07 W=5.9e-07
MXP10 nmin2in3 nmsel1 net97 VNW P18_DNW L=1.8e-07 W=5.9e-07
mX_g0_MXPA1 Y net97 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT MXI2D_X1_A7TR Y VDD VNW VPW VSS A B S0
mX_g0_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 net31 nmsel VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t2 nmin net31 B VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN0 nmin nmsel A VPW N18_DNW L=1.8e-07 W=4.3e-07
mX_g2_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g0_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 net31 nmsel VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t3 B nmsel nmin VNW P18_DNW L=1.8e-07 W=6.4e-07
MXP0 A net31 nmin VNW P18_DNW L=1.8e-07 W=6.4e-07
mX_g2_MXPA1 Y nmin VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT MXI2D_X2_A7TR Y VDD VNW VPW VSS A B S0
mX_g0_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=3.7e-07
mX_g1_MXNA1 net31 nmsel VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t2 nmin net31 B VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN1 nmin nmsel A VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g2_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g1_MXPA1 net31 nmsel VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t3 B nmsel nmin VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP0 A net31 nmin VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g2_MXPA1 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MXI2D_X4_A7TR Y VDD VNW VPW VSS A B S0
mX_g0_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mX_g1_MXNA1 net31 nmsel VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
MX_t2 nmin net31 B VPW N18_DNW L=1.8e-07 W=6.8e-07
MX_t2_2 nmin net31 B VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN2 nmin nmsel A VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN2_2 nmin nmsel A VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g2_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1_2 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mX_g1_MXPA1 net31 nmsel VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MX_t3 B nmsel nmin VNW P18_DNW L=1.8e-07 W=1.02e-06
MX_t3_2 B nmsel nmin VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP0 A net31 nmin VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP0_2 A net31 nmin VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g2_MXPA1 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1_2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MXI2D_X8_A7TR Y VDD VNW VPW VSS A B S0
mX_g0_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mX_g0_MXNA1_2 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g1_MXNA1 net31 nmsel VSS VPW N18_DNW L=1.8e-07 W=6.4e-07
mX_g1_MXNA1_2 net31 nmsel VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
MX_t2 nmin net31 B VPW N18_DNW L=1.8e-07 W=6.9e-07
MX_t2_2 nmin net31 B VPW N18_DNW L=1.8e-07 W=6.8e-07
MX_t2_3 nmin net31 B VPW N18_DNW L=1.8e-07 W=6.8e-07
MX_t2_4 nmin net31 B VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN3 nmin nmsel A VPW N18_DNW L=1.8e-07 W=6.9e-07
MXN3_2 nmin nmsel A VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN3_3 nmin nmsel A VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN3_4 nmin nmsel A VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g2_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1_2 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1_3 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1_4 Y nmin VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g0_MXPA1_2 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=1.13e-06
mX_g1_MXPA1 net31 nmsel VDD VNW P18_DNW L=1.8e-07 W=8e-07
mX_g1_MXPA1_2 net31 nmsel VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MX_t3 B nmsel nmin VNW P18_DNW L=1.8e-07 W=1.09e-06
MX_t3_2 B nmsel nmin VNW P18_DNW L=1.8e-07 W=1.07e-06
MX_t3_3 B nmsel nmin VNW P18_DNW L=1.8e-07 W=1.07e-06
MX_t3_4 B nmsel nmin VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP0 A net31 nmin VNW P18_DNW L=1.8e-07 W=7.1e-07
MXP0_2 A net31 nmin VNW P18_DNW L=1.8e-07 W=8.6e-07
MXP0_3 A net31 nmin VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP0_4 A net31 nmin VNW P18_DNW L=1.8e-07 W=1.26e-06
mX_g2_MXPA1 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1_2 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1_3 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1_4 Y nmin VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MXI2D_XL_A7TR Y VDD VNW VPW VSS A B S0
mX_g0_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 net31 nmsel VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t2 nmin net31 B VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 nmin nmsel A VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 Y nmin VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g0_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 net31 nmsel VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t3 B nmsel nmin VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1 A net31 nmin VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 Y nmin VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT MXI2_X12_A7TR Y VDD VNW VPW VSS A B S0
mXI16_MXNA1 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI16_MXNA1_2 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI16_MXNA1_3 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI16_MXNA1_4 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI16_MXNA1_5 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI16_MXNA1_6 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g0_MXNA1_2 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g0_MXNA1_3 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=6.9e-07
MXN5 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN5_2 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN5_3 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN5_4 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN5_5 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN5_6 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=8.1e-07
MX_t2 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=7.3e-07
MX_t2_2 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=6.7e-07
MX_t2_3 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=8.2e-07
MX_t2_4 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=8.2e-07
MX_t2_5 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=8.2e-07
MX_t2_6 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g2_MXNA1 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1_2 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1_3 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1_4 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1_5 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1_6 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI16_MXPA1 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI16_MXPA1_2 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI16_MXPA1_3 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI16_MXPA1_4 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI16_MXPA1_5 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI16_MXPA1_6 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g0_MXPA1_2 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g0_MXPA1_3 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP4 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP4_2 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP4_3 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP4_4 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP4_5 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP4_6 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=1.26e-06
MX_t3 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=1.03e-06
MX_t3_2 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=1.2e-06
MX_t3_3 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=1.2e-06
MX_t3_4 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=1.2e-06
MX_t3_5 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=1.2e-06
MX_t3_6 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=1.2e-06
mX_g2_MXPA1 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1_2 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1_3 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1_4 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1_5 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1_6 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MXI2_X1_A7TR Y VDD VNW VPW VSS A B S0
mX_g0_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
MX_t2 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN0 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g1_MXNA1 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g0_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=8.9e-07
MX_t3 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=8.9e-07
MX_t1 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g1_MXPA1 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT MXI2_X2_A7TR Y VDD VNW VPW VSS A B S0
mX_g0_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g2_MXNA1 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t2 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=8.8e-07
MXN0 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI11_MXNA1 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g2_MXPA1 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t3 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=1.26e-06
MX_t1 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI11_MXPA1 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MXI2_X3_A7TR Y VDD VNW VPW VSS A B S0
mXI12_MXNA1 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI12_MXNA1_2 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mX_g0_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN1 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=6.6e-07
MXN1_2 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=6.6e-07
MX_t2 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=6.6e-07
MX_t2_2 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=6.6e-07
mX_g2_MXNA1 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mX_g2_MXNA1_2 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI12_MXPA1 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
mXI12_MXPA1_2 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
mX_g0_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=7.7e-07
MXP0 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=9.9e-07
MXP0_2 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=9.9e-07
MX_t3 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=9.9e-07
MX_t3_2 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=9.9e-07
mX_g2_MXPA1 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
mX_g2_MXPA1_2 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=9.9e-07
.ends


.SUBCKT MXI2_X4_A7TR Y VDD VNW VPW VSS A B S0
mXI13_MXNA1 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI13_MXNA1_2 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN2 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN2_2 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=8.1e-07
MX_t2 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=7.5e-07
MX_t2_2 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=7.5e-07
mX_g2_MXNA1 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1_2 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI13_MXPA1 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=1.22e-06
mXI13_MXPA1_2 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=1.18e-06
mX_g0_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP1 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=1.17e-06
MXP1_2 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=1.26e-06
MX_t3 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=1.2e-06
MX_t3_2 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=1.2e-06
mX_g2_MXPA1 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1_2 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MXI2_X6_A7TR Y VDD VNW VPW VSS A B S0
mXI14_MXNA1 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI14_MXNA1_2 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI14_MXNA1_3 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
mX_g0_MXNA1_2 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN3 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN3_2 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN3_3 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=8.1e-07
MX_t2 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=7.5e-07
MX_t2_2 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=6.9e-07
MX_t2_3 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=8.1e-07
mX_g2_MXNA1 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1_2 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1_3 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI14_MXPA1 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI14_MXPA1_2 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI14_MXPA1_3 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
mX_g0_MXPA1_2 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=7.6e-07
MXP2 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP2_2 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP2_3 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=1.26e-06
MX_t3 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=1.05e-06
MX_t3_2 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=1.2e-06
MX_t3_3 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=1.2e-06
mX_g2_MXPA1 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1_2 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1_3 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends

.SUBCKT MXI2_X8_A7TR Y VDD VNW VPW VSS A B S0
mXI15_MXNA1 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=5.4e-07
mXI15_MXNA1_2 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI15_MXNA1_3 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI15_MXNA1_4 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=8.5e-07
mX_g0_MXNA1_2 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=5.1e-07
MXN4 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN4_2 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN4_3 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=8.1e-07
MXN4_4 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=8.1e-07
MX_t2 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=7.3e-07
MX_t2_2 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=6.7e-07
MX_t2_3 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=8.2e-07
MX_t2_4 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=8.2e-07
mX_g2_MXNA1 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1_2 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1_3 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g2_MXNA1_4 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI15_MXPA1 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI15_MXPA1_2 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI15_MXPA1_3 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI15_MXPA1_4 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g0_MXPA1_2 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP3 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP3_2 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP3_3 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=1.26e-06
MXP3_4 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=1.26e-06
MX_t3 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=1.03e-06
MX_t3_2 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=1.2e-06
MX_t3_3 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=1.2e-06
MX_t3_4 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=1.2e-06
mX_g2_MXPA1 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1_2 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1_3 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g2_MXPA1_4 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MXI2_XL_A7TR Y VDD VNW VPW VSS A B S0
mX_g0_MXNA1 nmsel S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 nmin1 B VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t2 Y S0 nmin1 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN1 Y nmsel nmin0 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI11_MXNA1 nmin0 A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g0_MXPA1 nmsel S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 nmin1 B VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
MX_t3 nmin1 nmsel Y VNW P18_DNW L=1.8e-07 W=5.6e-07
MXP0 nmin0 S0 Y VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI11_MXPA1 nmin0 A VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT MXI3_X1_A7TR Y VDD VNW VPW VSS A B C S0 S1
mX_g4_MXNA1 net86 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 net74 B VSS VPW N18_DNW L=1.8e-07 W=3.3e-07
MX_t6 nmin0in1 S0 net74 VPW N18_DNW L=1.8e-07 W=3.3e-07
MXN4 nmin0in1 net86 net80 VPW N18_DNW L=1.8e-07 W=3.3e-07
mX_g5_MXNA1 net80 A VSS VPW N18_DNW L=1.8e-07 W=3.3e-07
mX_g0_MXNA1 Y net115 VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXNA1 nmin2 C VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 net92 nmin2 VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
MX_t2 net115 S1 net92 VPW N18_DNW L=1.8e-07 W=4.3e-07
MXN5 net115 net104 net98 VPW N18_DNW L=1.8e-07 W=4.3e-07
mX_g2_MXNA1 net98 nmin0in1 VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
mX_g1_MXNA1 net104 S1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g4_MXPA1 net86 S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g6_MXPA1 net74 B VDD VNW P18_DNW L=1.8e-07 W=5e-07
MX_t7 net74 net86 nmin0in1 VNW P18_DNW L=1.8e-07 W=5e-07
MXP1 net80 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=5e-07
mX_g5_MXPA1 net80 A VDD VNW P18_DNW L=1.8e-07 W=5e-07
mX_g0_MXPA1 Y net115 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g7_MXPA1 nmin2 C VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 net92 nmin2 VDD VNW P18_DNW L=1.8e-07 W=6.4e-07
MX_t3 net92 net104 net115 VNW P18_DNW L=1.8e-07 W=6.4e-07
MXP3 net98 S1 net115 VNW P18_DNW L=1.8e-07 W=6.4e-07
mX_g2_MXPA1 net98 nmin0in1 VDD VNW P18_DNW L=1.8e-07 W=6.1e-07
mX_g1_MXPA1 net104 S1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT MXI3_X2_A7TR Y VDD VNW VPW VSS A B C S0 S1
mX_g5_MXNA1 net80 A VSS VPW N18_DNW L=1.8e-07 W=5.2e-07
MXN0 nmin0in1 net86 net80 VPW N18_DNW L=1.8e-07 W=5.3e-07
MX_t6 nmin0in1 S0 net74 VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g6_MXNA1 net74 B VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g4_MXNA1 net86 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nmin2 C VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 net92 nmin2 VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MX_t2 net115 S1 net92 VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN1 net115 net104 net98 VPW N18_DNW L=1.8e-07 W=4.5e-07
mX_g1_MXNA1 net104 S1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 net98 nmin0in1 VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g0_MXNA1 Y net115 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g5_MXPA1 net80 A VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MX_t5 net80 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=7.9e-07
MX_t7 net74 net86 nmin0in1 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g6_MXPA1 net74 B VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g4_MXPA1 net86 S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nmin2 C VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 net92 nmin2 VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
MX_t3 net92 net104 net115 VNW P18_DNW L=1.8e-07 W=9.6e-07
MXP0 net98 S1 net115 VNW P18_DNW L=1.8e-07 W=9.6e-07
mX_g1_MXPA1 net104 S1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 net98 nmin0in1 VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
mX_g0_MXPA1 Y net115 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MXI3_X4_A7TR Y VDD VNW VPW VSS A B C S0 S1
mX_g5_MXNA1 net80 A VSS VPW N18_DNW L=1.8e-07 W=5.2e-07
MXN0 nmin0in1 net86 net80 VPW N18_DNW L=1.8e-07 W=6.8e-07
MX_t6 nmin0in1 S0 net74 VPW N18_DNW L=1.8e-07 W=6e-07
mX_g6_MXNA1 net74 B VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g4_MXNA1 net86 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nmin2 C VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g3_MXNA1 net92 nmin2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t2 net115 S1 net92 VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN1 net115 net104 net98 VPW N18_DNW L=1.8e-07 W=4.5e-07
mX_g1_MXNA1 net104 S1 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g2_MXNA1 net98 nmin0in1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 Y net115 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 Y net115 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g5_MXPA1 net80 A VDD VNW P18_DNW L=1.8e-07 W=9.6e-07
MX_t5 net80 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=7.9e-07
MX_t7 net74 net86 nmin0in1 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g6_MXPA1 net74 B VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g4_MXPA1 net86 S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nmin2 C VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g3_MXPA1 net92 nmin2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t3 net92 net104 net115 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP0 net98 S1 net115 VNW P18_DNW L=1.8e-07 W=1e-06
mX_g1_MXPA1 net104 S1 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g2_MXPA1 net98 nmin0in1 VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
mX_g0_MXPA1 Y net115 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y net115 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MXI3_X8_A7TR Y VDD VNW VPW VSS A B C S0 S1
mX_g5_MXNA1 net80 A VSS VPW N18_DNW L=1.8e-07 W=5.2e-07
MXN0 nmin0in1 net86 net80 VPW N18_DNW L=1.8e-07 W=6.8e-07
MX_t6 nmin0in1 S0 net74 VPW N18_DNW L=1.8e-07 W=6e-07
mX_g6_MXNA1 net74 B VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g4_MXNA1 net86 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nmin2 C VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g3_MXNA1 net92 nmin2 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t2 net115 S1 net92 VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN1 net115 net104 net98 VPW N18_DNW L=1.8e-07 W=4.5e-07
mX_g1_MXNA1 net104 S1 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mX_g2_MXNA1 net98 nmin0in1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 Y net115 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 Y net115 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_3 Y net115 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_4 Y net115 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g5_MXPA1 net80 A VDD VNW P18_DNW L=1.8e-07 W=9.6e-07
MX_t5 net80 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=7.9e-07
MX_t7 net74 net86 nmin0in1 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g6_MXPA1 net74 B VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g4_MXPA1 net86 S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g7_MXPA1 nmin2 C VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g3_MXPA1 net92 nmin2 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t3 net92 net104 net115 VNW P18_DNW L=1.8e-07 W=1.32e-06
MXP0 net98 S1 net115 VNW P18_DNW L=1.8e-07 W=1e-06
mX_g1_MXPA1 net104 S1 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mX_g2_MXPA1 net98 nmin0in1 VDD VNW P18_DNW L=1.8e-07 W=8.6e-07
mX_g0_MXPA1 Y net115 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y net115 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_3 Y net115 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_4 Y net115 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MXI3_XL_A7TR Y VDD VNW VPW VSS A B C S0 S1
mX_g4_MXNA1 net86 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g6_MXNA1 net74 B VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t6 nmin0in1 S0 net74 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN2 nmin0in1 net86 net80 VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g5_MXNA1 net80 A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g0_MXNA1 Y net115 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g7_MXNA1 nmin2 C VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g3_MXNA1 net92 nmin2 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t2 net115 S1 net92 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN3 net115 net104 net98 VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g2_MXNA1 net98 nmin0in1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 net104 S1 VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g4_MXPA1 net86 S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g6_MXPA1 net74 B VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t7 net74 net86 nmin0in1 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP1 net80 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g5_MXPA1 net80 A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g0_MXPA1 Y net115 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g7_MXPA1 nmin2 C VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXPA1 net92 nmin2 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t3 net92 net104 net115 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP2 net98 S1 net115 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g2_MXPA1 net98 nmin0in1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 net104 S1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT MXI4_X1_A7TR Y VDD VNW VPW VSS A B C D S0 S1
mXI17_MXNA1 net102 C VSS VPW N18_DNW L=1.8e-07 W=3.3e-07
MXN0 nmin2in3 nmsel0 net102 VPW N18_DNW L=1.8e-07 W=3.3e-07
MX_t10 nmin2in3 S0 net100 VPW N18_DNW L=1.8e-07 W=3.3e-07
mX_g8_MXNA1 net100 D VSS VPW N18_DNW L=1.8e-07 W=3.3e-07
mX_g4_MXNA1 nmsel0 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI18_MXNA1 net104 B VSS VPW N18_DNW L=1.8e-07 W=3.3e-07
MXN1 nmin0in1 S0 net104 VPW N18_DNW L=1.8e-07 W=3.3e-07
MXN2 nmin0in1 nmsel0 net106 VPW N18_DNW L=1.8e-07 W=3.3e-07
mXI19_MXNA1 net106 A VSS VPW N18_DNW L=1.8e-07 W=3.3e-07
mX_g0_MXNA1 Y net99 VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mX_g3_MXNA1 net110 nmin2in3 VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
MX_t2 net99 S1 net110 VPW N18_DNW L=1.8e-07 W=4.3e-07
MXN3 net99 nmsel1 net112 VPW N18_DNW L=1.8e-07 W=4.3e-07
mXI20_MXNA1 net112 nmin0in1 VSS VPW N18_DNW L=1.8e-07 W=4.3e-07
mX_g1_MXNA1 nmsel1 S1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI17_MXPA1 net102 C VDD VNW P18_DNW L=1.8e-07 W=5e-07
MXP0 net102 S0 nmin2in3 VNW P18_DNW L=1.8e-07 W=5e-07
MX_t11 net100 nmsel0 nmin2in3 VNW P18_DNW L=1.8e-07 W=5e-07
mX_g8_MXPA1 net100 D VDD VNW P18_DNW L=1.8e-07 W=5e-07
mX_g4_MXPA1 nmsel0 S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI18_MXPA1 net104 B VDD VNW P18_DNW L=1.8e-07 W=5e-07
MXP1 net104 nmsel0 nmin0in1 VNW P18_DNW L=1.8e-07 W=5e-07
MXP2 net106 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=5e-07
mXI19_MXPA1 net106 A VDD VNW P18_DNW L=1.8e-07 W=5e-07
mX_g0_MXPA1 Y net99 VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mX_g3_MXPA1 net110 nmin2in3 VDD VNW P18_DNW L=1.8e-07 W=6.4e-07
MX_t3 net110 nmsel1 net99 VNW P18_DNW L=1.8e-07 W=6.4e-07
MXP3 net112 S1 net99 VNW P18_DNW L=1.8e-07 W=6.4e-07
mXI20_MXPA1 net112 nmin0in1 VDD VNW P18_DNW L=1.8e-07 W=6.4e-07
mX_g1_MXPA1 nmsel1 S1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT MXI4_X2_A7TR Y VDD VNW VPW VSS A B C D S0 S1
mXI17_MXNA1 net102 C VSS VPW N18_DNW L=1.8e-07 W=5.2e-07
MXN0 nmin2in3 nmsel0 net102 VPW N18_DNW L=1.8e-07 W=5.3e-07
MX_t10 nmin2in3 S0 net100 VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g8_MXNA1 net100 D VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g4_MXNA1 nmsel0 S0 VSS VPW N18_DNW L=1.8e-07 W=4.1e-07
mXI18_MXNA1 net104 B VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
MXN1 nmin0in1 S0 net104 VPW N18_DNW L=1.8e-07 W=4.2e-07
MXN2 nmin0in1 nmsel0 net106 VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI19_MXNA1 net106 A VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g0_MXNA1 Y net99 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g3_MXNA1 net110 nmin2in3 VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MX_t2 net99 S1 net110 VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN3 net99 nmsel1 net112 VPW N18_DNW L=1.8e-07 W=4.9e-07
mXI20_MXNA1 net112 nmin0in1 VSS VPW N18_DNW L=1.8e-07 W=4.9e-07
mX_g1_MXNA1 nmsel1 S1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI17_MXPA1 net102 C VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP0 net102 S0 nmin2in3 VNW P18_DNW L=1.8e-07 W=7.9e-07
MX_t11 net100 nmsel0 nmin2in3 VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g8_MXPA1 net100 D VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g4_MXPA1 nmsel0 S0 VDD VNW P18_DNW L=1.8e-07 W=6.1e-07
mXI18_MXPA1 net104 B VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP4 net104 nmsel0 nmin0in1 VNW P18_DNW L=1.8e-07 W=7.9e-07
MXP2 net106 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=7.9e-07
mXI19_MXPA1 net106 A VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mX_g0_MXPA1 Y net99 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g3_MXPA1 net110 nmin2in3 VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
MX_t3 net110 nmsel1 net99 VNW P18_DNW L=1.8e-07 W=8.2e-07
MXP5 net112 S1 net99 VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI20_MXPA1 net112 nmin0in1 VDD VNW P18_DNW L=1.8e-07 W=8.5e-07
mX_g1_MXPA1 nmsel1 S1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT MXI4_X4_A7TR Y VDD VNW VPW VSS A B C D S0 S1
mXI17_MXNA1 net102 C VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN0 nmin2in3 nmsel0 net102 VPW N18_DNW L=1.8e-07 W=6.8e-07
MX_t10 nmin2in3 S0 net100 VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g8_MXNA1 net100 D VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g4_MXNA1 nmsel0 S0 VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI18_MXNA1 net104 B VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN4 nmin0in1 S0 net104 VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN5 nmin0in1 nmsel0 net106 VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI19_MXNA1 net106 A VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g3_MXNA1 net110 nmin2in3 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t2 net99 S1 net110 VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN3 net99 nmsel1 net112 VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g1_MXNA1 nmsel1 S1 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI20_MXNA1 net112 nmin0in1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 Y net99 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 Y net99 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI17_MXPA1 net102 C VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP0 net102 S0 nmin2in3 VNW P18_DNW L=1.8e-07 W=1.02e-06
MX_t11 net100 nmsel0 nmin2in3 VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g8_MXPA1 net100 D VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g4_MXPA1 nmsel0 S0 VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mXI18_MXPA1 net104 B VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP6 net104 nmsel0 nmin0in1 VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP7 net106 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI19_MXPA1 net106 A VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g3_MXPA1 net110 nmin2in3 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t3 net110 nmsel1 net99 VNW P18_DNW L=1.8e-07 W=1.24e-06
MXP5 net112 S1 net99 VNW P18_DNW L=1.8e-07 W=1.18e-06
mX_g1_MXPA1 nmsel1 S1 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI20_MXPA1 net112 nmin0in1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1 Y net99 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y net99 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MXI4_X8_A7TR Y VDD VNW VPW VSS A B C D S0 S1
mXI17_MXNA1 net102 C VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN0 nmin2in3 nmsel0 net102 VPW N18_DNW L=1.8e-07 W=6.8e-07
MX_t10 nmin2in3 S0 net100 VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g8_MXNA1 net100 D VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g4_MXNA1 nmsel0 S0 VSS VPW N18_DNW L=1.8e-07 W=5.3e-07
mXI18_MXNA1 net104 B VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN4 nmin0in1 S0 net104 VPW N18_DNW L=1.8e-07 W=6.8e-07
MXN5 nmin0in1 nmsel0 net106 VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI19_MXNA1 net106 A VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mX_g3_MXNA1 net110 nmin2in3 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
MX_t2 net99 S1 net110 VPW N18_DNW L=1.8e-07 W=8.2e-07
MXN3 net99 nmsel1 net112 VPW N18_DNW L=1.8e-07 W=5.3e-07
mX_g1_MXNA1 nmsel1 S1 VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI20_MXNA1 net112 nmin0in1 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1 Y net99 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_2 Y net99 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_3 Y net99 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mX_g0_MXNA1_4 Y net99 VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI17_MXPA1 net102 C VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP0 net102 S0 nmin2in3 VNW P18_DNW L=1.8e-07 W=1.02e-06
MX_t11 net100 nmsel0 nmin2in3 VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g8_MXPA1 net100 D VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mX_g4_MXPA1 nmsel0 S0 VDD VNW P18_DNW L=1.8e-07 W=7.9e-07
mXI18_MXPA1 net104 B VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP6 net104 nmsel0 nmin0in1 VNW P18_DNW L=1.8e-07 W=1.02e-06
MXP7 net106 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI19_MXPA1 net106 A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mX_g3_MXPA1 net110 nmin2in3 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
MX_t3 net110 nmsel1 net99 VNW P18_DNW L=1.8e-07 W=1.24e-06
MXP5 net112 S1 net99 VNW P18_DNW L=1.8e-07 W=1.18e-06
mX_g1_MXPA1 nmsel1 S1 VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI20_MXPA1 net112 nmin0in1 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1 Y net99 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_2 Y net99 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_3 Y net99 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mX_g0_MXPA1_4 Y net99 VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT MXI4_XL_A7TR Y VDD VNW VPW VSS A B C D S0 S1
mXI17_MXNA1 net102 C VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN4 nmin2in3 nmsel0 net102 VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t10 nmin2in3 S0 net100 VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g8_MXNA1 net100 D VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI23_MXNA1 nmsel0 S0 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI24_MXNA1 net104 B VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN5 nmin0in1 S0 net104 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN8 nmin0in1 nmsel0 net106 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI19_MXNA1 net106 A VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g0_MXNA1 Y net99 VSS VPW N18_DNW L=1.8e-07 W=4.2e-07
mX_g3_MXNA1 net110 nmin2in3 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
MX_t2 net99 S1 net110 VPW N18_DNW L=1.8e-07 W=2.8e-07
MXN9 net99 nmsel1 net112 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI20_MXNA1 net112 nmin0in1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mX_g1_MXNA1 nmsel1 S1 VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI17_MXPA1 net102 C VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP4 net102 S0 nmin2in3 VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t11 net100 nmsel0 nmin2in3 VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g8_MXPA1 net100 D VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI23_MXPA1 nmsel0 S0 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI24_MXPA1 net104 B VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP5 net104 nmsel0 nmin0in1 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP6 net106 S0 nmin0in1 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI19_MXPA1 net106 A VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g0_MXPA1 Y net99 VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mX_g3_MXPA1 net110 nmin2in3 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
MX_t3 net110 nmsel1 net99 VNW P18_DNW L=1.8e-07 W=4.2e-07
MXP7 net112 S1 net99 VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI20_MXPA1 net112 nmin0in1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mX_g1_MXPA1 nmsel1 S1 VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
.ends


.SUBCKT NAND2B_X12_A7TR Y VDD VNW VPW VSS AN B
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA1_2 a AN VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA1_3 a AN VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXNA2_2 XI1_n1__2 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y a XI1_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y a XI1_n1__3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_3 XI1_n1__3 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_4 XI1_n1__4 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y a XI1_n1__4 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_5 Y a XI1_n1__5 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_5 XI1_n1__5 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_6 XI1_n1__6 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_6 Y a XI1_n1__6 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y a XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2 XI1_n1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 a AN VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI0_MXPA1_3 a AN VDD VNW P18_DNW L=1.8e-07 W=1.02e-06
mXI1_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y a VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y a VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_3 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y a VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y a VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_4 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_5 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_5 Y a VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_6 Y a VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_6 Y B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT NAND2B_X1_A7TR Y VDD VNW VPW VSS AN B
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 XI1_n1 B VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXNA1 Y a XI1_n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPA1 Y a VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT NAND2B_X2_A7TR Y VDD VNW VPW VSS AN B
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI1_MXNA2 XI1_n1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y a XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y a VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND2B_X4_A7TR Y VDD VNW VPW VSS AN B
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXNA2_2 XI1_n1__2 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y a XI1_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y a XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2 XI1_n1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y a VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y a VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT NAND2B_X8_A7TR Y VDD VNW VPW VSS AN B
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI0_MXNA1_2 a AN VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXNA2_2 XI1_n1__2 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y a XI1_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_3 Y a XI1_n1__3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_3 XI1_n1__3 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_4 XI1_n1__4 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_4 Y a XI1_n1__4 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y a XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2 XI1_n1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 a AN VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y a VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y a VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_3 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_3 Y a VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_4 Y a VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_4 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND2B_XL_A7TR Y VDD VNW VPW VSS AN B
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 XI1_n1 B VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y a XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=4.2e-07
mXI1_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPA1 Y a VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT NAND2_X12_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2_2 XI0_n1__2 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A XI0_n1__3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_3 XI0_n1__3 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_4 XI0_n1__4 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A XI0_n1__4 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_5 Y A XI0_n1__5 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_5 XI0_n1__5 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_6 XI0_n1__6 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_6 Y A XI0_n1__6 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_3 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_4 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_5 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_5 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_6 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_6 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND2_X1_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXNA1 Y A XI0_n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends

.SUBCKT NAND2_X2_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND2_X3_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2_2 XI0_n1__2 B VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA1_2 Y A XI0_n1__2 VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA1 Y A XI0_n1 VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=6.6e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
.ends


.SUBCKT NAND2_X4_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2_2 XI0_n1__2 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND2_X5_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2_2 XI0_n1__2 B VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA1_2 Y A XI0_n1__2 VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA1_3 Y A XI0_n1__3 VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA2_3 XI0_n1__3 B VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXNA1 Y A XI0_n1 VPW N18_DNW L=1.8e-07 W=7.3e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI0_MXPA2_3 Y B VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.1e-06
.ends


.SUBCKT NAND2_X6_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2_2 XI0_n1__2 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A XI0_n1__3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_3 XI0_n1__3 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_3 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND2_X8_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2_2 XI0_n1__2 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A XI0_n1__3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_3 XI0_n1__3 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_4 XI0_n1__4 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A XI0_n1__4 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_3 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_4 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND2_XL_A7TR Y VDD VNW VPW VSS A B
mXI0_MXNA2 XI0_n1 B VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXNA1 Y A XI0_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT NAND3B_X1_A7TR Y VDD VNW VPW VSS AN B C
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA3 XI1_n1 C VSS VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXNA2 XI1_n2 B XI1_n1 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXNA1 Y a XI1_n2 VPW N18_DNW L=1.8e-07 W=4.4e-07
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
mXI1_MXPA1 Y a VDD VNW P18_DNW L=1.8e-07 W=9.4e-07
.ends


.SUBCKT NAND3B_X2_A7TR Y VDD VNW VPW VSS AN B C
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=3.4e-07
mXI1_MXNA3 XI1_n1 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2 XI1_n2 B XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y a XI1_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=5.1e-07
mXI1_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y a VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND3B_X4_A7TR Y VDD VNW VPW VSS AN B C
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=6.8e-07
mXI1_MXNA3_2 XI1_n1__2 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2_2 XI1_n2__2 B XI1_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1_2 Y a XI1_n2__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA1 Y a XI1_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA2 XI1_n2 B XI1_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI1_MXNA3 XI1_n1 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI1_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1 Y a VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA1_2 Y a VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI1_MXPA3_2 Y C VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
.ends


.SUBCKT NAND3B_XL_A7TR Y VDD VNW VPW VSS AN B C
mXI0_MXNA1 a AN VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA3 XI1_n1 C VSS VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA2 XI1_n2 B XI1_n1 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI1_MXNA1 Y a XI1_n2 VPW N18_DNW L=1.8e-07 W=2.8e-07
mXI0_MXPA1 a AN VDD VNW P18_DNW L=1.8e-07 W=4.4e-07
mXI1_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
mXI1_MXPA1 Y a VDD VNW P18_DNW L=1.8e-07 W=5.6e-07
.ends


.SUBCKT NAND3_X12_A7TR Y VDD VNW VPW VSS A B C
mXI0_MXNA3_2 XI0_n1__2 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_2 XI0_n2__2 B XI0_n1__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_2 Y A XI0_n2__2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_3 Y A XI0_n2__3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_3 XI0_n2__3 B XI0_n1__3 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_3 XI0_n1__3 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_4 XI0_n1__4 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_4 XI0_n2__4 B XI0_n1__4 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_4 Y A XI0_n2__4 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_5 Y A XI0_n2__5 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_5 XI0_n2__5 B XI0_n1__5 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_5 XI0_n1__5 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3_6 XI0_n1__6 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2_6 XI0_n2__6 B XI0_n1__6 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1_6 Y A XI0_n2__6 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA1 Y A XI0_n2 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA2 XI0_n2 B XI0_n1 VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXNA3 XI0_n1 C VSS VPW N18_DNW L=1.8e-07 W=8.8e-07
mXI0_MXPA3 Y C VDD VNW P18_DNW L=1.8e-07 W=9.8e-07
mXI0_MXPA2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1 Y A VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1_2 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_2 Y B VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA3_2 Y C VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA3_3 Y C VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA2_3 Y B VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
mXI0_MXPA1_3 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA1_4 Y A VDD VNW P18_DNW L=1.8e-07 W=1.32e-06
mXI0_MXPA2_4 Y B VDD VNW P18_DNW L=1.8e-07 W=1.16e-06
